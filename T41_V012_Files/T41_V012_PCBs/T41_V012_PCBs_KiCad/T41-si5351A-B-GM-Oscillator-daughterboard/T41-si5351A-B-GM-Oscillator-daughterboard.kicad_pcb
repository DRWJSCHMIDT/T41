# Repository DRWJSCHMIDT/T41

File README.md:

# T41_Stuff

This is the repository for the officially released V10, V11, and V12 versions of the T41 Software Defined Transceiver hardware and kits.  Please read the areas below to understand this project, order boards, make your own boards, find build part lists (BOMs), order kits, and documentation that supports the T41 project.

What is the T41 project?

## KiCad design T41_V012_Files/T41_V012_PCBs/T41_V012_PCBs_KiCad/T41-si5351A-B-GM-Oscillator-daughterboard/T41-si5351A-B-GM-Oscillator-daughterboard.kicad_pcb

Parts:
C1, C2, C3, C4, C5: 0.1uF 50V; C_0603_1608Metric; LCSC C14663
G1: qwiic_Logo; qwiic_4mm; not fitted
H1, H2: MountingHole; MountingHole_2.2mm_M2_DIN965; not fitted
J1: qwiic; JST_SH_SM04B-SRSS-TB_1x04-1MP_P1.00mm_Horizontal; LCSC C160404
J2: pin header; PinHeader_1x04_P2.54mm_Vertical; not fitted
J3, J4: pin header; PinHeader_1x06_P2.54mm_Vertical; not fitted
J5: OEBSSEN; PinHeader_1x03_P2.54mm_Vertical; not fitted
JP1, JP2, JP3, JP4: SolderJumper_2_Open; SolderJumper-2_P1.3mm_Open_TrianglePad1.0x1.5mm
L1, L2, L3, L4: FB; L_0603_1608Metric; LCSC C1002
R1, R2: 2k2; R_0603_1608Metric; LCSC C4190; not fitted
U1: Si5351A-B-GM; QFN-20-1EP_4x4mm_P0.5mm_EP2.7x2.7mm; LCSC C22413806
U2: ECS-TX053-S3; Oscillator_ECS_TXO53_S3; LCSC C18457614; not fitted
U3: ECS-TXO-2520-250-TR; Oscillator_SMD_ECS_2520MV-xxx-xx-4Pin_2.5x2.0mm; not fitted
U4: ECS-TXO-3225-100-TR; ECSTXO3225120TR; Manufacturer_Part_Number ECS-TXO-3225-100-TR

Connections:
+3V3: J1.2, J2.3, JP1.1 (A), L1.2, L2.1, L3.1, L4.1, R1.1, R2.1
/0/RX0: J3.1, U1.13 (CLK0)
/1/RX90: J3.2, U1.12 (CLK1)
/4/TX90: J4.6, U1.19 (CLK4)
/5/TX0: J4.5, U1.17 (CLK5)
/6/CW: J4.3, U1.16 (CLK6)
/CLK2: J3.4, U1.9 (CLK2)
/CLK3: J3.5, U1.8 (CLK3)
/CLK7: J4.2, U1.15 (CLK7)
/SCL: J1.4, J2.1, R2.2, U1.4 (SCL)
/SDA: J1.3, J2.2, R1.2, U1.5 (SDA)
GND: C1.2, C3.2, C4.2, C5.2, J1.1, J2.4, J3.3, J3.6, J4.1, J4.4, J5.3, JP2.2 (B), JP4.1 (A), U1.21 (GND), U2.1 (GND), U2.4 (GND), U3.2 (GND), U4.2 (GND); also elsewhere on the board
unnamed: J5.1, U1.7 (OEB)
unnamed: J5.2, U1.6 (SSEN)
unnamed: JP1.2 (B), JP2.1 (A), U1.3 (A0)
unnamed: JP3.1 (A), JP4.2 (B), U2.3 (TRISTATE), U3.1 (Tri-State), U4.1 (TSTS)
unnamed: C1.1, JP3.2 (B), L1.1, U2.9 (VDD), U3.4 (VDD), U4.4 (VDD)
unnamed: C4.1, L2.2, U1.18 (VDDOC), U1.20 (VDD)
unnamed: C3.1, L3.2, U1.10 (VDDOB), U1.11 (VDDOA)
unnamed: C5.1, L4.2, U1.14 (VDDOD)
unnamed: C2.1, U1.1 (XA)
unnamed 21: C2.2, U2.6 (OUT), U3.3 (OUT), U4.3 (OUT); also elsewhere on the board

Notes on the sheet:
Option 1: 10-SMD 5.0 x 3.2
Option 2: 4-SMD 2.5 x 2.0
Option 3: 4-SMD 3.2 x 2.5

Board: 4 copper layers, 35.1 x 25.3 mm, 28 parts (0 on the bottom side), 22 nets.

Other parts of the board:
J6: PinHeader_1x02_P2.54mm_Vertical

Their connections:
GND: J6.2; also elsewhere on the board
unnamed 21: J6.1; also elsewhere on the board

## KiCad design T41_V012_Files/T41_V012_PCBs/T41_V012_PCBs_KiCad/T41-RF-board-V012.8/T41-RF-board-V012.8.kicad_pcb

Parts:
C1, C3, C11, C12, C14, C32, C35, C36, C39, C41, C42, C57, C60, C67, C71: 10uF 50V; C_1206_3216Metric; LCSC C13585
C2, C9, C15, C24: 1uF 50V; C_1206_3216Metric; LCSC C1848
C4, C10, C17, C28, C37, C54: 10nF 50V; C_1206_3216Metric; LCSC C1846
C5, C21: 105pF 50V; C_1206_3216Metric; LCSC C1884
C6, C7, C13, C16, C18, C20, C22, C23, C25, C26, C27, C29, C30, C31, C40, C43, C45, C47, C53, C55, C56, C58, C59, C61, C62, C63, C64, C65, C68, C70, C72, C73, C80: 0.1uF 50V; C_1206_3216Metric; LCSC C24497
C8, C19: 180pF 50V; C_1206_3216Metric; LCSC C527293
C33, C46: 2.2nF 50V; C_1206_3216Metric; LCSC C326631
C34, C38, C44, C50: 0.2uF 50V; C_1206_3216Metric; LCSC C1857
C69: 470uF 25V; CP_Radial_D10.0mm_P5.00mm
G1, G2, G3, G4, G5, G6: TestPoint; PinHeader_1x01_P2.54mm_Vertical; not fitted
H1: MountingHole_3.2mm_M3_Pad
H5, H6: MountingHole_4.3mm_M4_DIN965_Pad
J1: IQ_Out; Jack_3.5mm_STX-3081_Horizontal
J2: RF_IN; SMA_Amphenol_901-144_Vertical
J3: RFControl; IDC-Header_2x05_P2.54mm_Vertical
J4: 12-13.8V; TerminalBlock_bornier-2_P5.08mm
J5: IQ_In; Jack_3.5mm_STX-3081_Horizontal
J6: RF_OUT; SMA_Amphenol_901-144_Vertical
JP1, JP15, JP16, JP17: SolderJumper_2_Open; SolderJumper-2_P1.3mm_Open_TrianglePad1.0x1.5mm
JP2: SolderJumper_2_Bridged; SolderJumper-2_P1.3mm_Bridged_RoundedPad1.0x1.5mm
JP4: CAL isolation; PinHeader_1x02_P2.54mm_Vertical; not fitted
L1, L2, L3, L5, L6, L7, L8, L9: FB; R_1206_3216Metric; LCSC C74486
L4, L10: 1.5uH; R_1206_3216Metric; LCSC C395022
L11, L12, L13: 10uH 20%; L_Bourns-SRN6028; LCSC C5753503
Q1: BS170; TO-92
R1, R13: 2k; R_1206_3216Metric; LCSC C17944
R2, R3, R5, R6, R10, R11, R17, R18: 5k1; R_1206_3216Metric; LCSC C26033
R4, R8, R16, R22, R54: 100R; R_1206_3216Metric; LCSC C17901
R7, R9, R12, R15, R19, R20, R21, R23, R30, R39, R44, R47: 10k; R_1206_3216Metric; LCSC C17902
R14: 36R5; R_1206_3216Metric; LCSC C205349
R24, R28, R35, R37, R40, R42, R53, R55, R64, R65, R66, R67: 0; R_1206_3216Metric; LCSC C17888
R25, R29, R32, R36, R41, R46: 10k 1%; R_1206_3216Metric; LCSC C17902
R26, R34, R49, R50, R51, R60, R61, R62, R63: 2k2; R_1206_3216Metric; LCSC C17948
R27, R33, R38, R43: 49R9 1%; R_1206_3216Metric; LCSC C2984401
R31, R45: 2k2 1%; R_1206_3216Metric; LCSC C17948
R48, R73: 100k; R_1206_3216Metric; LCSC C17900
R52, R59: 1k1; R_1206_3216Metric; LCSC C17889
R56: 1k6; R_1206_3216Metric; LCSC C17896
R57: 330R; R_1206_3216Metric; LCSC C17930
R58: 51k; R_1206_3216Metric; LCSC C17992
TP1, TP2, TP3, TP4, TP5, TP6, TP7, TP8, TP9, TP10, TP11, TP12, TP13, TP14, TP17, TP18: TestPoint; PinHeader_1x01_P2.54mm_Vertical; not fitted
TR1: ADT1-1; Mini-Circuits_CD542_H2.84mm; LCSC C2683432
TR2: ADT2-1T; Mini-Circuits_CD542_H2.84mm; LCSC C5223988
U1, U4: 74CBTLV3253DR; SOIC-16_3.9x9.9mm_P1.27mm; LCSC C543079
U2: PSA-8A+; SOT-363_SC-70-6; LCSC C3192212
U3, U11: Attenuator Daughter Board (See Legend); T41_Attenuator_Daughter
U5, U10: SN74LVC1G04DCK; SOT-SC70; LCSC C8207
U6, U8: MC33078; SOIC-8_3.9x4.9mm_P1.27mm; LCSC C2057560
U7, U9: MASWSS0179; MASWSS0179-SOT-26; LCSC C3304462
U12: Oscillator Daughter Board (See Legend); T41_DualClock_Daughter
U13: MAR-3SM+; Mini-Circuits_WW107; LCSC C6937326
U14: LM7805CT; TO-220-3_Vertical; LCSC C725349
U15: LM1117T-3.3; TO-220-3_Vertical; LCSC C201726
U16: LM358B; SOIC-8_3.9x4.9mm_P1.27mm; LCSC C1850238
U17: LM317L; SOIC-8_3.9x4.9mm_P1.27mm; LCSC C183332
U21: MCP23017_SO; SOIC-28W_7.5x17.9mm_P1.27mm; LCSC C47023
U106: AD8599; SOIC-8_3.9x4.9mm_P1.27mm; LCSC C207971
U107: OPA2209; SOIC-8_3.9x4.9mm_P1.27mm; LCSC C2057330

Connections:
+3V3: C80.2, JP2.2 (B), L5.1, L6.1, L11.2, R39.2, R49.2, R51.2, R60.2, R61.2, R62.2, R63.2, TP18.1, U3.4 (3V3), U5.5 (VCC), U10.5 (VCC), U11.4 (3V3), U12.7 (3V3), U21.9 (VDD)
+5V: C18.1, C61.1, JP1.2 (B), L2.2, L3.2, L7.1, L8.2, L9.2, L12.2, TP17.1
+12V: C69.1, C70.1, L13.2, U14.1 (VI), U15.3 (VI), U16.8 (V+), U17.1 (VI)
/CW: C62.2, U12.4 (CLK6)
/CW on/off: J3.7, R58.2
/Cal: J3.10, U9.4 (V2), U10.2
/ExciterEnable: C31.1, C55.2, Q1.1 (D), R39.1, U4.1 (1~OE), U4.15 (2~OE)
/I_out: J1.T, R65.2, TP3.1
/Q_out: J1.R, R64.2, TP2.1
/RC0.5: U11.1 (0.5dB), U21.21 (GPA0)
/RC1: U11.12 (1dB), U21.22 (GPA1)
/RC2: U11.11 (2dB), U21.23 (GPA2)
/RC4: U11.10 (4dB), U21.24 (GPA3)
/RC8: U11.9 (8dB), U21.25 (GPA4)
/RC16: U11.6 (16dB), U21.26 (GPA5)
/RFIN: C58.2, JP4.1 (A)
/RX0: R42.1, U12.12 (CLK0)
/RX90: R40.1, U12.11 (CLK1)
/RXTX: J3.9, R47.2
/SCL: J3.1, R49.1, U12.5 (SCL), U21.12 (SCK)
/SDA: J3.3, R51.1, U12.6 (SDA), U21.13 (SDA)
/TC0.5: U3.1 (0.5dB), U21.1 (GPB0)
/TC1: U3.12 (1dB), U21.2 (GPB1)
/TC2: U3.11 (2dB), U21.3 (GPB2)
/TC4: U3.10 (4dB), U21.4 (GPB3)
/TC8: U3.9 (8dB), U21.5 (GPB4)
/TC16: U3.6 (16dB), U21.6 (GPB5)
/TX0: R37.2, U12.2 (CLK5)
/TX90: R35.2, U12.1 (CLK4)
/X Mode: J3.6, U5.2, U7.6 (V1)
GND: C1.1, C3.1, C4.1, C6.1, C7.1, C8.1, C10.1, C11.1, C12.1, C13.1, C14.1, C17.1, C18.2, C19.1, C20.1, C23.1, C25.2, C26.2, C28.1, C30.1, C31.2, C32.1, C34.2, C35.1, C36.1, C37.2, C38.2, C39.2, C40.1, C41.2, C42.1, C44.2, C50.2, C54.2, C55.1, C56.1, C57.2, C59.1, C60.2, C61.2, C64.2, C65.2, C67.2, C68.2, C69.2, C70.2, C71.2, C72.2, C73.1, C80.1, G1.1, G2.1, G3.1, G4.1, G5.1, G6.1, H1.1, H5.1, H6.1, J1.S, J2.2 (Ext), J3.2, J3.4, J3.5, J4.2, J5.S, J6.2 (Ext), JP15.1 (A), JP16.1 (A), JP17.1 (A), Q1.3 (S), R9.2, R12.2, R19.2, R23.2, R34.1, R48.2, R52.1, R59.2, R73.2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
unnamed: C1.2, R3.1
unnamed: C2.1, C4.2, R4.1, TP1.1
unnamed: C5.1, R2.2, R64.1, U107.1
unnamed: C5.2, R5.2, R6.1
unnamed: C9.1, C10.2, R8.1
unnamed: C11.2, R10.1
unnamed: C12.2, C13.2, L7.2, R14.1
unnamed: C15.1, C17.2, R16.1, TP5.1
unnamed: C16.2, TR1.3
unnamed: C20.2, R15.2, R19.1, R20.1
unnamed: C21.1, R11.2, R65.1, U107.7
unnamed: C21.2, R17.2, R18.1
unnamed: C22.1, TP4.1, TR1.4
unnamed: C24.1, C28.2, R22.1
unnamed: C33.1, R24.2, R25.2, R32.1, U6.1
unnamed: C37.1, R25.1, R30.2, R31.1
unnamed: C40.2, C41.1, R26.1, R34.2, TR2.5
unnamed: C43.1, TR2.3
unnamed: C46.1, R36.2, R46.1, R53.2, U8.1
unnamed: C54.1, R36.1, R44.2, R45.1
unnamed: C16.1, J2.1 (In), JP4.2 (B)
unnamed: J4.1, L13.1
unnamed: J5.R, R66.2, TP9.1
unnamed: J5.T, R67.2, TP14.1
unnamed: C53.2, J6.1 (In)
unnamed: JP1.1 (A), JP2.1 (A), L1.1, R15.1
unnamed: JP15.2 (B), R60.1, U21.15 (A0)
unnamed: JP16.2 (B), R61.1, U21.16 (A1)
unnamed: JP17.2 (B), R63.1, U21.17 (A2)
unnamed: L4.1, R14.2
unnamed: L6.2, R26.2
unnamed: L10.1, R54.1
unnamed: C56.2, Q1.2 (G), R47.1, R48.1
unnamed: R1.2, R5.1, U106.1
unnamed: R13.2, R17.1, U106.7
unnamed: R24.1, R27.1
unnamed: R28.1, R33.1
unnamed: R28.2, R29.2, U6.7
unnamed: R30.1, R66.1
unnamed: R38.1, R53.1
unnamed: R41.2, R55.2, U8.7
unnamed: R43.1, R55.1
unnamed: R44.1, R67.1
unnamed: R54.2, R57.1, U17.2 (VO), U17.3 (VO), U17.6 (VO), U17.7 (VO)
unnamed: C27.2, R20.2, TP6.1, U1.7 (1A), U1.9 (2A)
unnamed: C2.2, U1.6 (1B1), U1.10 (2B1)
unnamed: C15.2, U1.5 (1B2), U1.11 (2B2)
unnamed: C24.2, U1.4 (1B3), U1.12 (2B3)
unnamed: C9.2, U1.3 (1B4), U1.13 (2B4)
unnamed: R12.1, U1.1 (1~OE), U1.15 (2~OE)
unnamed: R42.2, U1.14 (S0)
unnamed: R40.2, U1.2 (S1)
unnamed: C3.2, C6.2, L1.2, U1.16 (VCC)
unnamed: C29.2, U2.3 (IN)
unnamed: C27.1, L4.2, U2.6 (OUT)
unnamed: C63.1, U3.2 (RF1)
unnamed: C45.2, U3.8 (RF2)
unnamed: TP8.1, TR2.6, U4.7 (1A)
unnamed: C38.1, R33.2, TP10.1, U4.6 (1B1), U4.13 (2B4)
unnamed: C50.1, R43.2, TP13.1, U4.5 (1B2), U4.12 (2B3)
unnamed: C44.1, R38.2, TP11.1, U4.4 (1B3), U4.11 (2B2)
unnamed: C34.1, R27.2, TP7.1, U4.3 (1B4), U4.10 (2B1)
unnamed: TP12.1, TR2.4, U4.9 (2A)
unnamed: R37.1, U4.14 (S0)
unnamed: R35.1, U4.2 (S1)
unnamed: C30.2, C42.2, L5.2, U4.16 (VCC)
unnamed: C39.1, C57.1, C59.2, C60.1, R50.1, R52.2, U6.3 (+), U6.5 (+), U8.3 (+), U8.5 (+)
unnamed: C33.2, R31.2, U6.2 (-)
unnamed: R29.1, R32.2, U6.6 (-)
unnamed: C35.2, C64.1, L8.1, U6.8 (V+)
unnamed: C43.2, U7.1 (RF1)
unnamed: C47.2, U7.3 (RF2)
unnamed: C45.1, U7.5 (RFC)
unnamed: U5.4, U7.4 (V2)
unnamed: C46.2, R45.2, U8.2 (-)
unnamed: R41.1, R46.2, U8.6 (-)
unnamed: C36.2, C65.1, L9.1, R50.2, U8.8 (V+)
unnamed: C53.1, U9.1 (RF1)
unnamed: C58.1, U9.3 (RF2)
unnamed: C63.2, U9.5 (RFC)
unnamed: U9.6 (V1), U10.4
unnamed: C22.2, U11.2 (RF1)
unnamed: C29.1, U11.8 (RF2)
unnamed: C62.1, U13.1 (IN)
unnamed: C47.1, L10.2, U13.3 (OUT)
unnamed: C67.1, C68.1, L12.1, U14.3 (VO)
unnamed: C71.1, C72.1, L11.1, U15.2 (VO)
unnamed: C73.2, R58.1, R73.1, U16.3 (+)
unnamed: R56.2, R59.1, U16.2 (-)
unnamed: R56.1, R57.2, U16.1, U17.4 (ADJ)
unnamed: R62.1, U21.18 (~RESET)
unnamed: R7.2, R8.2, R9.1, U106.3 (+)
unnamed: R1.1, R4.2, U106.2 (-)
unnamed: R21.2, R22.2, R23.1, U106.5 (+)
unnamed: R13.1, R16.2, U106.6 (-)
unnamed: C7.2, C14.2, C23.2, C25.1, L3.1, R7.1, R21.1, U106.8 (V+)
unnamed: C8.2, R6.2, U107.3 (+)
unnamed: R2.1, R3.2, U107.2 (-)
unnamed: C19.2, R18.2, U107.5 (+)
unnamed: R10.2, R11.1, U107.6 (-)
unnamed: C26.1, C32.2, L2.1, U107.8 (V+)

Notes on the sheet:
Attenuator Daughter Board Options ---------------------------- 1. Single PE4312 Attenuator Daughterboard 2. Dual PE4312 Attenuator Daughterboard
RF output
RF input from filter board
Amplifier biasing
IQ out to main board Ring - Q Tip - I
Oscillator Daughter Board Options ---------------------------- 1. si5351A-B-GM Oscillator Daughterboard 2. si5340 Oscillator Daughterboard
CW Mode
R73 stacked on top of C73
10T
RF RECEIVE CHAIN ->
Select 5V if needed for large signal operation.
ADDRESS SELECT
Tx On/Off: High = Tx on
SSB Mode
IQ in from main board Ring - Q Tip - I
MiniCircuits ADT2-1T+
MiniCircuits ADT1-1+
<- RF TRANSMIT CHAIN
RF control breakout
Oscillator
Auto calibrate switch
Power supply
Mode select
Inverting and phasing op-amps
Transmit RF Gain Control
Input RF amplifier
Low-pass 200 kHz Anti-aliasing Filter
Summing transformer
I2C options control
RxTx: HIGH = Tx on X Mode: HIGH = SSB LOW = CW CW: H = on, L = off
Quadrature sampling exciter
Quadrature Sampling Detector
Receive RF gain control
Misc. holes
CW envelope shaping
Board mounting holes

Board: 4 copper layers, 100.0 x 100.0 mm, 209 parts (0 on the bottom side), 132 nets.

## KiCad design T41_V012_Files/T41_V012_PCBs/T41_V012_PCBs_KiCad/T41-Single-PE4312-Attenuator-daughterboard/T41-Single-PE4312-Attenuator-daughterboard.kicad_pcb

Parts:
C1: 0.1uF 50V; C_0603_1608Metric; LCSC C14663
C2: 10uF 50V; C_0603_1608Metric; LCSC C96446
J1: Conn 1; PinHeader_1x06_P2.54mm_Vertical; not fitted
J2: Conn 2; PinHeader_1x06_P2.54mm_Vertical; not fitted
L1: FB; R_0603_1608Metric; LCSC C1002
R1, R2: 10k; R_0603_1608Metric; LCSC C25804
U1: PE4312; PE4312-QFN-20; LCSC C500480

Connections:
+3V3: J1.4, L1.1
/TC0.5: J1.1, U1.20 (C0.5)
/TC1: J2.1, U1.19 (C1)
/TC2: J2.2, U1.17 (C2)
/TC4: J2.3, U1.16 (C4)
/TC8: J2.4, U1.15 (C8)
/TC16: J1.6, R2.2
GND: C1.1, C2.1, J1.3, J1.5, J2.6, R1.1, U1.7 (PUP1), U1.8 (PUP2), U1.10 (GND), U1.11 (GND), U1.12 (VSS), U1.13 (P/S), U1.18 (GND), U1.21 (GND)
unnamed: J1.2, U1.2 (RF1)
unnamed: J2.5, U1.14 (RF2)
unnamed: R2.1, U1.1 (C16)
unnamed: R1.2, U1.3 (Data)
unnamed: C1.2, C2.2, L1.2, U1.5 (LE), U1.6 (VDD), U1.9 (VDD)

Board: 2 copper layers, 14.6 x 17.0 mm, 8 parts (0 on the bottom side), 13 nets.

File T41_V012_Files/T41_V012_PCBs/T41_V012_PCBs_KiCad/T41-RF-board-Attenuator-daughterboard/T41-RF-board-Attenuator-daughterboard-BOM.csv:

Reference,Qty,Value,DNP,Footprint,Datasheet,LCSC
C1,1,0.1uF 50V,,Capacitor_SMD:C_0603_1608Metric,~,C14663
C2,1,10uF 50V,,Capacitor_SMD:C_0603_1608Metric,~,C96446
J1,1,Conn 1,DNP,Connector_PinHeader_2.54mm:PinHeader_1x06_P2.54mm_Vertical,~,
J2,1,Conn 2,DNP,Connector_PinHeader_2.54mm:PinHeader_1x06_P2.54mm_Vertical,~,
L1,1,FB,,Resistor_SMD:R_0603_1608Metric,~,C1002
"R1,R2",2,10k,,Resistor_SMD:R_0603_1608Metric,~,C25804
U1,1,PE4312,,T41_Library:PE4312-QFN-20,https://www.psemi.com/pdf/datasheets/pe4312ds.pdf,C500480

## KiCad design T41_V012_Files/T41_V012_PCBs/T41_V012_PCBs_KiCad/T41-RF-board-DualClock-daughterboard/DualClockLO.kicad_pcb

Parts:
C1, C2, C3, C4, C5: 0.1uF 50V; C_0603_1608Metric
G1: qwiic_Logo; qwiic_4mm; not fitted
H1, H2: MountingHole; MountingHole_2.2mm_M2_DIN965; not fitted
J1: qwiic; JST_SH_SM04B-SRSS-TB_1x04-1MP_P1.00mm_Horizontal
J2: pin header; PinHeader_1x04_P2.54mm_Vertical; not fitted
J3, J4: pin header; PinHeader_1x06_P2.54mm_Vertical; not fitted
J5: OEBSSEN; PinHeader_1x03_P2.54mm_Vertical; not fitted
JP1: GND select; SolderJumper-2_P1.3mm_Bridged_RoundedPad1.0x1.5mm; not fitted
JP2: SolderJumper_2_Open; SolderJumper-2_P1.3mm_Open_TrianglePad1.0x1.5mm; not fitted
L1, L2, L3, L4: FB; L_0603_1608Metric
R1, R2: 2k2; R_0603_1608Metric
Y1: ECS-TX053-S3; Oscillator_ECS_TXO53_S3
Y2: 25MHz; Crystal_SMD_HC49-SD_HandSoldering
Y3: Si5351A-B-GM; QFN-20-1EP_4x4mm_P0.5mm_EP2.7x2.7mm

Connections:
+3V3: J1.2, J2.3, JP1.1 (A), L1.2, L2.1, L3.1, L4.1, R1.1, R2.1
/0/RX0: J3.1, Y3.13 (CLK0)
/1/RX90: J3.2, Y3.12 (CLK1)
/4/TX90: J4.6, Y3.19 (CLK4)
/5/TX0: J4.5, Y3.17 (CLK5)
/6/CW: J4.3, Y3.16 (CLK6)
/CLK2: J3.4, Y3.9 (CLK2)
/CLK3: J3.5, Y3.8 (CLK3)
/CLK7: J4.2, Y3.15 (CLK7)
/SCL: J1.4, J2.1, R2.2, Y3.4 (SCL)
/SDA: J1.3, J2.2, R1.2, Y3.5 (SDA)
GND: C1.2, C3.2, C4.2, C5.2, J1.1, J2.4, J3.3, J3.6, J4.1, J4.4, J5.3, JP2.2 (B), Y1.1 (GND), Y1.4 (GND), Y3.21 (GND)
unnamed: J5.1, Y3.7 (OEB)
unnamed: J5.2, Y3.6 (SSEN)
unnamed: JP1.2 (B), JP2.1 (A), Y3.3 (A0)
unnamed: C2.2, Y1.6 (OUT)
unnamed: C1.1, L1.1, Y1.9 (VDD)
unnamed: C4.1, L2.2, Y3.18 (VDDOC), Y3.20 (VDD)
unnamed: C3.1, L3.2, Y3.10 (VDDOB), Y3.11 (VDDOA)
unnamed: C5.1, L4.2, Y3.14 (VDDOD)
unnamed: C2.1, Y2.1, Y3.1 (XA)
unnamed: Y2.2, Y3.2 (XB)

Notes on the sheet:
Optional: TCXO upgrade

Board: 4 copper layers, 35.1 x 25.3 mm, 24 parts (0 on the bottom side), 22 nets.

File T41_V012_Files/T41_V012_PCBs/T41_V012_PCBs_KiCad/T41-RF-board-DualClock-daughterboard-OH5KB/BOM_DualClockLO.csv:

"Reference","Qty","Value","Exclude from BOM","Exclude from Board","Footprint","LCSC"
"C1,C2,C3,C4,C5","5","0.1uF 50V","","","Capacitor_SMD:C_0603_1608Metric","C14663"
"J3,J4","2","pin header","","","Connector_PinHeader_2.54mm:PinHeader_1x06_P2.54mm_Vertical",""
"J5","1","qwiic","","","Connector_JST:JST_SH_SM04B-SRSS-TB_1x04-1MP_P1.00mm_Horizontal","C160404"
"L1,L2,L3,L4","4","FB","","","Inductor_SMD:L_0603_1608Metric","C1002"
"Y1","1","8122S-25.000NQ33FTL","","","Oscillator:Oscillator_SMD_Abracon_ASE-4Pin_3.2x2.5mm","C20623084"
"Y4","1","Si5351A-B-GM","","","Package_DFN_QFN:QFN-20-1EP_4x4mm_P0.5mm_EP2.7x2.7mm","C22413806"

Notices in the files:
K9HZ_100W_PA/K9HZ_100W_KiCad/K9HZ_100W_KiCad.kicad_pcb:
Copyright 2024 WJ Schmidt - K9HZ
Copyright 2023
