# Repository DRWJSCHMIDT/T41 (continued)

## KiCad design T41_V012_Mini_Files/T41_V012_Mini_Projects/T41-mini-Main+RF-board-V012/T41-Main+RF-board-V012.kicad_pcb

Parts:
C1, C3, C7, C9, C10, C11, C13, C17, C18, C19, C25, C26: 0.1uF 50V; C_1206_3216Metric; Mouser C1206C104K5RACTU
C2, C5, C6: 470uF 25V; CP_Radial_D10.0mm_P5.00mm; Mouser 667-ECA-1EM471
C4, C8, C12, C15, C20, C21, C22, C27, C28, C29: 10uF 16V; C_1206_3216Metric; Mouser 80-C1206C106K4P
C14, C16: 2.2uF 16V; C_1206_3216Metric; Mouser 80-C1206C225K5R
C23, C24: 2.2nF; C_1206_3216Metric; Mouser 80-C1206C222K5RAC
C30, C40, C44, C51, C55, C60, C61, C63, C68, C69, C70, C71, C72, C73, C74, C75, C85, C86, C87, C88, C89, C90, C91, C92, C99, C100: 0.1uF 50V; C_1206_3216Metric
C31, C32, C33, C34, C35, C36, C37, C43, C47, C48, C52, C54: 0.01uF 50V; C_1206_3216Metric
C38, C39, C45, C46, C53, C56, C57, C58, C59, C62, C76, C93, C94: 10uF 50V; C_1206_3216Metric
C41, C42, C81, C82, C83, C84: 10nF 50V; C_1206_3216Metric
C49, C50: 2.2nF 50V; C_1206_3216Metric
C64, C65, C66, C67: 0.2uF 50V; C_1206_3216Metric
C77, C78, C79, C80: 1uF 50V; C_1206_3216Metric
C95, C97: 180pF 50V; C_1206_3216Metric
C96, C98: 105pF 50V; C_1206_3216Metric
D1, D2: LED; LED_D3.0mm
Encoder1, Encoder2, Encoder3, Encoder4: RotaryEncoder_Switch; RotaryEncoder_Bourns_Vertical_PEC12R-3x17F-Sxxxx
H1, H2: EA-T220-38E; EAT22038E; Mouser Part Number 588-EA-T220-38E
H3, H4, H5, H6: MountingHole_4.3mm_M4_DIN965_Pad
J1: 12-13.8V; TerminalBlock_bornier-2_P5.08mm
J2: Display; PinHeader_2x04_P2.54mm_Vertical
J3: PA+BPF+LPF; PinHeader_2x04_P2.54mm_Vertical
J4: USBHost; IDC-Header_2x03_P2.54mm_Vertical; Mouser 710-61200621621
J5: Keys/PTT; IDC-Header_2x03_P2.54mm_Vertical
J6: Rec_Out; Jack_3.5mm_STX-3081_Horizontal; Mouser 490-SJ1-3515N
J7: Mic_In; Jack_3.5mm_STX-3081_Horizontal; Mouser 490-SJ1-3515N
J8: Header; PinHeader_1x02_P2.54mm_Vertical
J9: RX RF in; PinHeader_1x02_P2.54mm_Vertical
J10: TX RF Out; PinHeader_1x02_P2.54mm_Vertical
J11: PA POWER +12V; PinHeader_2x06_P2.54mm_Vertical
JP1: SolderJumper_2_Open; SolderJumper-2_P1.3mm_Open_TrianglePad1.0x1.5mm
JP2: SolderJumper_2_Bridged; SolderJumper-2_P1.3mm_Bridged_RoundedPad1.0x1.5mm
L1: 10uH 20%; L_Bourns-SRN6028
L2, L3: 10uH 20%; L_Bourns-SRN6028; Mouser 81-1264EY-100MP3
L4, L5, L7, L8, L9, L10, L12, L13: FB; R_1206_3216Metric
L6, L11: 1.5uH; R_1206_3216Metric
Q1: BS170; TO-92
R1: 2K2; R_1206_3216Metric; Mouser CRCW12062K20JNEAC
R2, R3: 470R; R_1206_3216Metric; Mouser CRCW1206470RJNEAC
R4, R5, R6: 100R; R_1206_3216Metric; Mouser 652-CR1206FX-1000ELF
R7, R27: 2.2K; R_1206_3216Metric
R8, R9: 330; R_1206_3216Metric
R10, R11, R28, R32, R33, R34, R47, R48, R49, R50: 10k; R_1206_3216Metric
R12, R13: 2k2 1%; R_1206_3216Metric
R14, R15, R18, R19, R20, R21: 10k 1%; R_1206_3216Metric
R16, R17, R35, R36, R53, R54: 2k2; R_1206_3216Metric
R22, R23, R24, R25: 49R9 1%; R_1206_3216Metric
R26: 36R5; R_1206_3216Metric
R29, R30: 500R; R_1206_3216Metric
R31, R37: 100k; R_1206_3216Metric
R38: 51k; R_1206_3216Metric
R39, R40, R41, R42, R52: 100R; R_1206_3216Metric
R43: 1k2; R_1206_3216Metric
R44, R45: 2k; R_1206_3216Metric
R46: 1k8; R_1206_3216Metric
R51: 330R; R_1206_3216Metric
R55, R56, R57, R58, R59, R60, R61, R62: 5k1; R_1206_3216Metric
R63, R64: 0; R_1206_3216Metric
SW1, SW2, SW3, SW4, SW5, SW6, SW7, SW8, SW9, SW10, SW11, SW12, SW13, SW14, SW15, SW16, SW17, SW18: SW_Omron_B3FS; SW_SPST_B3S-1000
TP1, TP2, TP3, TP4, TP5, TP6, TP7, TP8, TP9, TP10, TP11, TP12, TP13: TestPoint; PinHeader_1x01_P2.54mm_Vertical
TR1: ADT2-1T; Mini-Circuits_CD542_H2.84mm
U1: LM7805CT; TO-220-3_Vertical; Mouser 926-LM7805CT/NOPB
U2: LM1117T-3.3; TO-220-3_Vertical; Mouser 926-LM1117T-3.3/NOPB
U3: Teensy4.1; Teensy41
U4: PCM5102; TSSOP-20_4.4x6.5mm_P0.65mm; Mouser 595-PCM5102APWR
U5: PCM1808PW; TSSOP-14_4.4x5mm_P0.65mm; Mouser 595-PCM1808PW
U6, U12: MCP23017_SO; SOIC-28W_7.5x17.9mm_P1.27mm
U7: Teensy_Audio_Adaptor
U8, U9: MC33078; SOIC-8_3.9x4.9mm_P1.27mm
U10: PSA-8A+; SOT-363_SC-70-6
U11, U13: 74CBTLV3253DR; SOIC-16_3.9x9.9mm_P1.27mm
U14: MAR-3SM+; Mini-Circuits_WW107
U15: Si5351A-B-GT; MSOP-10_3x3mm_P0.5mm
U16: AD8599; SOIC-8_3.9x4.9mm_P1.27mm
U17: MASWSS0179; MASWSS0179-SOT-26
U18: LM358B; SOIC-8_3.9x4.9mm_P1.27mm
U19: SN74LVC1G04DCK; SOT-SC70
U20: LM317L; SOIC-8_3.9x4.9mm_P1.27mm
U21: OPA2209; SOIC-8_3.9x4.9mm_P1.27mm
Y1: 25MHz; Crystal_SMD_HC49-SD_HandSoldering

Connections:
+3V3: C7.1, C8.1, C11.1, C12.1, C13.1, C15.1, C18.1, C21.1, C30.2, C63.2, JP2.2 (B), L2.2, L7.1, L8.1, L10.1, R1.2, R7.1, R27.1, R33.2, R53.2, R54.2, TP2.1, U4.1 (CPVDD), U4.8 (AVDD), U4.20 (DVDD), U5.4 (VDD), U6.9 (VDD), U6.17 (A2), U12.9 (VDD), U19.5 (VCC)
+5V: C1.1, C4.2, C17.1, C20.1, C25.1, C40.1, C61.2, C62.2, C100.1, J2.3, J2.4, J3.6, JP1.2 (B), L3.2, L4.2, L5.2, L12.2, L13.2, R26.1, TP1.1, U3.48 (VIN), U5.3 (VCC)
+12P: J1.1, J11.1, J11.2, J11.3, J11.4, J11.5, J11.6, L1.1
+12V: C2.1, C3.1, L1.2, U1.1 (VI), U2.3 (VI), U18.8 (V+), U20.1 (VI)
/ADC_IN: U3.8 (6_OUT1D), U5.9 (DOUT)
/BAND0: J3.1, U3.19 (27_A13_SCK1)
/BAND1: J3.2, U3.20 (28_RX7)
/BAND2: J3.3, U3.21 (29_TX7)
/BAND3: J3.4, U3.22 (30_CRX3)
/BAND4: J3.5, U3.23 (31_CTX3)
/BCK: R6.1, U3.43 (21_A7_RX5_BCLK1), U4.13 (BCK), U7.21 (BCLK)
/CLK: R4.1, U3.45 (23_A9_CRX1_MCLK1), U7.23 (MCLK)
/CW: R38.2, U3.25 (33_MCLK2)
/C/S: J2.5, U3.12 (10_CS_MQSR)
/D+: J4.3, U3.57 (D+)
/D-: J4.6, U3.56 (D-)
/DAUDIO_OUT: U3.24 (32_OUT1B), U4.14 (DIN)
/ExciterEnable: C72.2, C73.1, Q1.1 (D), R33.1, U11.1 (1~OE), U11.15 (2~OE)
/INT1: U3.36 (14_A0_TX3_SPDIF_OUT), U12.20 (INTA)
/INT2: U3.37 (15_A1_RX3_SPDIF_IN), U6.20 (INTA)
/Key1 in: J5.6, U3.28 (36_CS)
/Key2 in: J5.4, U3.27 (35_TX8)
/LRCK: R5.1, U3.42 (20_A6_TX5_LRCLK1), U4.15 (LRCK), U7.20 (LRCLK)
/MISO: J2.6, U3.14 (12_MISO_MQSL)
/MOSI: J2.7, U3.13 (11_MOSI_CTX1)
/PTT in: J5.3, J7.R, U3.29 (37_CS)
/RX I: R64.2, TP13.1, U5.14 (VIN_R)
/RX Q: R63.2, TP12.1, U5.13 (VIN_L)
/RXTX: J3.7, R28.2, U3.44 (22_A8_CTX1)
/Rx: U3.10 (8_TX2_IN1), U7.8 (Rx)
/SCL: R54.1, U3.41 (19_A5_SCL), U7.19 (SCL), U15.4 (SCL)
/SCL1: U3.38 (16_A2_RX4_SCL1), U6.12 (SCK), U12.12 (SCK)
/SCLK: J2.8, U3.35 (13_SCK_LED)
/SDA: R53.1, U3.40 (18_A4_SDA), U7.18 (SDA), U15.5 (SDA)
/SDA1: U3.39 (17_A3_TX4_SDA1), U6.13 (SDA), U12.13 (SDA)
/TX I: C39.2, U7.2 (I)
/TX Mode: U3.26 (34_RX8), U17.6 (V1), U19.2
/TX Q: C38.2, U7.1 (Q)
/Tx: U3.9 (7_RX2_OUT1A), U7.7 (Tx)
GND: C1.2, C2.2, C3.2, C4.1, C5.2, C6.2, C7.2, C8.2, C9.2, C10.2, C11.2, C12.2, C13.2, C14.2, C15.2, C17.2, C18.2, C19.2, C20.2, C21.2, C22.2, C23.2, C24.1, C25.2, C26.2, C29.2, C30.1, C31.2, C32.2, C33.1, C34.2, C35.1, C36.2, C37.1, C40.2, C41.2, C42.2, C43.1, C44.2, C45.2, C46.2, C47.2, C48.1, C51.1, C52.2, C53.2, C54.2, C60.2, C61.1, C62.1, C63.1, C64.2, C65.2, C66.2, C67.2, C69.1, C70.1, C71.1, C72.1, C73.2, C74.1, C75.1, C76.2, C81.1, C82.1, C83.1, C84.1, C88.1, C89.2, C90.1, C91.2, C92.1, C93.1, C94.1, C95.1, C97.1, C99.2, C100.2, Encoder1.C, Encoder1.S2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
unnamed: C23.1, C27.1, R2.1
unnamed: C24.2, C28.1, R3.1
unnamed: C27.2, J6.T
unnamed: C28.2, J6.R
unnamed: C38.1, R10.1
unnamed: C39.1, R11.1
unnamed: C41.1, R10.2, R12.1, R14.1
unnamed: C42.1, R11.2, R13.1, R15.1
unnamed: C49.1, C56.1, R14.2, R18.1, U9.1
unnamed: C50.1, C58.1, R15.2, R19.1, U8.1
unnamed: C56.2, R22.1
unnamed: C57.1, R20.2, U9.7
unnamed: C57.2, R23.1
unnamed: C58.2, R24.1
unnamed: C59.1, R21.2, U8.7
unnamed: C59.2, R25.1
unnamed: C70.2, R29.2, R30.1, R32.1
unnamed: C75.2, C76.1, R35.1, R36.2, TR1.5
unnamed: C77.1, C81.2, R41.1, TP11.1
unnamed: C78.1, C82.2, R42.1
unnamed: C79.1, C83.2, R39.1, TP10.1
unnamed: C80.1, C84.2, R40.1
unnamed: C86.1, TR1.3
unnamed: C93.2, R57.1
unnamed: C94.2, R59.1
unnamed: C96.1, R61.2, R63.1, U21.1
unnamed: C96.2, R55.2, R58.1
unnamed: C98.1, R62.2, R64.1, U21.7
unnamed: C98.2, R56.2, R60.1
unnamed: D1.2 (A), U6.28 (GPA7)
unnamed: D1.1 (K), R8.2
unnamed: D2.2 (A), U6.27 (GPA6)
unnamed: D2.1 (K), R9.2
unnamed: J4.5, U3.55 (5V)
unnamed: J7.S, J8.1
unnamed: J7.T, J8.2
unnamed: C55.1, J9.2
unnamed: J10.1, U17.5 (RFC)
unnamed: JP1.1 (A), JP2.1 (A), L9.1, R29.1
unnamed: L6.1, R26.2
unnamed: L8.2, R35.2
unnamed: L11.1, R52.1
unnamed: C69.2, Q1.2 (G), R28.1, R31.1
unnamed: R44.2, R55.1, U16.1
unnamed: R45.2, R56.1, U16.7
unnamed: R51.1, R52.2, U20.2 (VO), U20.3 (VO), U20.6 (VO), U20.7 (VO)
unnamed: C5.1, C9.1, L3.1, U1.3 (VO)
unnamed: C6.1, C10.1, L2.1, U2.2 (VO)
unnamed: C16.2, U4.4 (CAPM)
unnamed: C16.1, U4.2 (CAPP)
unnamed: C19.1, C22.1, U4.18 (LDOO)
unnamed: R2.2, U4.6 (OUTL)
unnamed: R3.2, U4.7 (OUTR)
unnamed: C14.1, U4.5 (VNEG)
unnamed: R1.1, U4.17 (XSMT)
unnamed: R6.2, U5.8 (BCK)
unnamed: R5.2, U5.7 (LRCK)
unnamed: R4.2, U5.6 (SCKI)
unnamed: C26.1, C29.1, U5.1 (VREF)
unnamed: SW17.1, U6.21 (GPA0)
unnamed: SW18.1, U6.22 (GPA1)
unnamed: C36.1, Encoder1.S1, U6.23 (GPA2)
unnamed: C52.1, Encoder2.S1, U6.24 (GPA3)
unnamed: C54.1, Encoder4.S1, U6.25 (GPA4)
unnamed: C33.2, Encoder3.S1, U6.26 (GPA5)
unnamed: C34.1, Encoder1.A, U6.1 (GPB0)
unnamed: C32.1, Encoder1.B, U6.2 (GPB1)
unnamed: C47.1, Encoder2.A, U6.3 (GPB2)
unnamed: C31.1, Encoder2.B, U6.4 (GPB3)
unnamed: C35.2, Encoder3.A, U6.5 (GPB4)
unnamed: C37.2, Encoder3.B, U6.6 (GPB5)
unnamed: C43.2, Encoder4.A, U6.7 (GPB6)
unnamed: C48.2, Encoder4.B, U6.8 (GPB7)
unnamed: R7.2, U6.18 (~RESET)
unnamed: C45.1, C46.1, C51.2, C53.1, R16.1, R17.2, U8.3 (+), U8.5 (+), U9.3 (+), U9.5 (+)
unnamed: C50.2, R13.2, U8.2 (-)
unnamed: R19.2, R21.1, U8.6 (-)
unnamed: C44.1, L4.1, R16.2, U8.8 (V+)
unnamed: C49.2, R12.2, U9.2 (-)
unnamed: R18.2, R20.1, U9.6 (-)
unnamed: C60.1, L5.1, U9.8 (V+)
unnamed: C55.2, U10.3 (IN)
unnamed: C68.1, L6.2, U10.6 (OUT)
unnamed: TP8.1, TR1.6, U11.7 (1A)
unnamed: C65.1, R23.2, TP4.1, U11.6 (1B1), U11.13 (2B4)
unnamed: C67.1, R25.2, TP6.1, U11.5 (1B2), U11.12 (2B3)
unnamed: C66.1, R24.2, TP5.1, U11.4 (1B3), U11.11 (2B2)
unnamed: C64.1, R22.2, TP3.1, U11.3 (1B4), U11.10 (2B1)
unnamed: TP9.1, TR1.4, U11.9 (2A)
unnamed: U11.14 (S0), U13.14 (S0), U15.9 (CLK1)
unnamed: U11.2 (S1), U13.2 (S1), U15.10 (CLK0)
unnamed: C71.2, L7.2, U11.16 (VCC)
unnamed: SW1.1, U12.21 (GPA0)
unnamed: SW2.1, U12.22 (GPA1)
unnamed: SW3.1, U12.23 (GPA2)
unnamed: SW4.1, U12.24 (GPA3)
unnamed: SW5.1, U12.25 (GPA4)
unnamed: SW6.1, U12.26 (GPA5)
unnamed: SW7.1, U12.27 (GPA6)
unnamed: SW8.1, U12.28 (GPA7)
unnamed: SW9.1, U12.1 (GPB0)
unnamed: SW10.1, U12.2 (GPB1)
unnamed: SW11.1, U12.3 (GPB2)
unnamed: SW12.1, U12.4 (GPB3)
unnamed: SW13.1, U12.5 (GPB4)
unnamed: SW14.1, U12.6 (GPB5)
unnamed: SW15.1, U12.7 (GPB6)
unnamed: SW16.1, U12.8 (GPB7)
unnamed: R27.2, U12.18 (~RESET)
unnamed: C68.2, R32.2, TP7.1, U13.7 (1A), U13.9 (2A)
unnamed: C77.2, U13.6 (1B1), U13.10 (2B1)
unnamed: C79.2, U13.5 (1B2), U13.11 (2B2)
unnamed: C80.2, U13.4 (1B3), U13.12 (2B3)
unnamed: C78.2, U13.3 (1B4), U13.13 (2B4)
unnamed: R34.1, U13.1 (1~OE), U13.15 (2~OE)
unnamed: C74.2, L9.2, U13.16 (VCC)
unnamed: C85.1, U14.1 (IN)
unnamed: C87.1, L11.2, U14.3 (OUT)
unnamed: C85.2, U15.6 (CLK2)
unnamed: C89.1, L10.2, U15.1 (VDD), U15.7 (VDDO)
unnamed: U15.2 (XA), Y1.1
unnamed: U15.3 (XB), Y1.2
unnamed: R42.2, R47.2, R48.1, U16.3 (+)
unnamed: R41.2, R44.1, U16.2 (-)
unnamed: R40.2, R49.2, R50.1, U16.5 (+)
unnamed: R39.2, R45.1, U16.6 (-)
unnamed: C90.2, C91.1, C92.2, L12.1, R47.1, R49.1, U16.8 (V+)
unnamed: C86.2, U17.1 (RF1)
unnamed: C87.2, U17.3 (RF2)
unnamed: U17.4 (V2), U19.4
unnamed: C88.2, R37.1, R38.1, U18.3 (+)
unnamed: R43.1, R46.2, U18.2 (-)
unnamed: R46.1, R51.2, U18.1, U20.4 (ADJ)
unnamed: C95.2, R58.2, U21.3 (+)
unnamed: R57.2, R61.1, U21.2 (-)
unnamed: C97.2, R60.2, U21.5 (+)
unnamed: R59.2, R62.1, U21.6 (-)
unnamed: C99.1, L13.1, U21.8 (V+)

Notes on the sheet:
Amplifier biasing
L_out
R_out
CW Mode
R73 stacked on top of C73
Headphones
Select 5V if needed for large signal operation.
MIC INPUT Ring - PTT Top - MONO Audio
Tx On/Off: High = Tx on
SSB Mode
AUDIO OUT RING - RIGHT TIP - LEFT
MiniCircuits ADT2-1T+
Board mounting holes
Heatsinks
Inverting and phasing op-amps
Low-pass 200 kHz Anti-aliasing Filter
Clock generator
Quadrature sampling exciter
Quadrature Sampling Detector
CW envelope shaping

Board: 2 copper layers, 255 parts (0 on the bottom side), 174 nets, no tracks yet.

## KiCad design K9HZ_100W_PA/K9HZ_100W_KiCad/K9HZ_100W_KiCad.kicad_pcb

Board: 2 copper layers, 124.9 x 83.6 mm, 74 parts (1 on the bottom side), 34 nets.

Parts:
C2, C4, C7, C9, C10, C15, C18, C20, C23, C24: 0.1uF 50V; C_1206_3216Metric
C3: 2.2uF 6V; C_1206_3216Metric
C5: 1uF 16V; C_1206_3216Metric
C6: 10uF 6V; C_1206_3216Metric
C11, C12, C13, C14: 0.1uF; C_1206_3216Metric
C16, C17: 1uF 50V; C_1206_3216Metric
C19, C21, C22: 0.01uF 50V; C_1206_3216Metric
C25, C26: 4.7nF 100V; C_1206_3216Metric
C27, C28: 470pF 200V; C_1812_4532Metric_Pad1.57x3.40mm_HandSolder
C29: 0.1uF; C_1812_4532Metric_Pad1.57x3.40mm_HandSolder
D1: 7.1V 1W; D_SOD-323_HandSoldering
D2, D3: 1N4148; D_SOD-523
D6, D7, D8, D9: 3.6V; D_DO-35_SOD27_P7.62mm_Horizontal
H1, H2, H3, H4: MountingHole_4.3mm_M4_DIN965_Pad
J1: BANDS; IDC-Header_2x05_P2.54mm_Vertical
J2: RF_IN; SMA_Amphenol_901-144_Vertical
J4: 12V, 20A; TerminalBlock_bornier-2_P5.08mm
J5: RF_OUT; SMA_Amphenol_901-144_Vertical
J7: Temp monitor; PinHeader_1x04_P2.54mm_Vertical
L2: FB; L_Axial_L5.3mm_D2.2mm_P7.62mm_Horizontal_Vishay_IM-1
L3: FB; L_1206_3216Metric_Pad1.22x1.90mm_HandSolder
Q1: BSS84; SOT-23
Q2: BS170; TO-92_Inline
Q3: BD677; TO-126-3_Horizontal_TabUp
Q4: RD100HHF1C; RD100HHF1-suspended
Q5: RD100HHF1C; RD100HHF1-suspended-v2
R4, R5: 5k6; R_1206_3216Metric
R7: 3.0k 1%; R_1206_3216Metric
R8: 0.005 Ohm 4W; R_2010_5025Metric_Pad1.40x2.65mm_HandSolder
R9: 3k; R_1206_3216Metric
R10: 510R; R_1206_3216Metric
R11: 6k8; R_1206_3216Metric
R12, R13: 10R; R_1206_3216Metric
R14: 200R 2W; R_Axial_DIN0411_L9.9mm_D3.6mm_P12.70mm_Horizontal
R15, R17: 220R; R_1206_3216Metric
R16, R18: 10R 1W; R_2010_5025Metric_Pad1.40x2.65mm_HandSolder
R19, R20: 150R 3W; R_Axial_DIN0614_L14.3mm_D5.7mm_P25.40mm_Horizontal
RV1, RV2: 500R; Potentiometer_Bourns_3296W_Vertical
T1: BN43-2402; Toroid_6Pin_BN-43-2402_7mm_6.2mm
T2: BN43-3312; Toroid_6Pin_BN-43-3312_19.5mm_25.4mm
U2: AP7381-33Y-13; SOT-89-3
U3: MCP3021A0T-E/OT; SOT-23-5_HandSoldering
U4: ZXCT1010; SOT-23-5
U5: L4931CDT50; SO-8_3.9x4.9mm_P1.27mm

Connections:
+3V3: C2.2, C3.2, J7.4, L2.1, L3.1, U2.1 (VO)
+12P: C9.2, C11.1, C12.1, C13.1, C14.1, C16.2, R8.1, R10.1, T2.4 (SC), U4.5 (Vs-), U5.8 (VI)
+12V: C4.2, C5.2, C9.1, C10.1, J4.2, R8.2, U2.3 (VI), U4.4 (Vs+)
/RXTX: C20.2, J1.10, Q2.2 (G), R11.2
/SCL: J1.7, J7.1, R4.2, U3.5 (SCL)
/SDA: J1.5, J7.2, R5.2, U3.4 (SDA)
GND: C2.1, C3.1, C4.1, C5.1, C6.1, C7.1, C10.2, C11.2, C12.2, C13.2, C14.2, C16.1, C17.1, C18.1, C19.1, C20.1, C23.2, C24.1, D1.2 (A), D6.2 (A), D9.2 (A), H1.1, H2.1, H3.1, H4.1, J1.9, J2.2 (Ext), J4.1, J5.2 (Ext), J7.3, Q2.3 (S), Q3.3 (E), Q4.2 (S), Q5.2 (S), R7.1, R11.1, T1.2 (AB), T2.1 (AA), U2.2 (GND), U3.2 (VSS), U4.2 (GND), U5.2 (GND), U5.3 (GND), U5.6 (GND), U5.7 (GND)
unnamed: C21.1, R12.2
unnamed: C22.1, R13.2
unnamed: C25.1, R19.2
unnamed: C26.1, R20.2
unnamed: D1.1 (K), Q2.1 (D), R9.1, R10.2
unnamed: C23.1, D2.2 (A), R15.1, RV1.2
unnamed: D2.1 (K), R15.2, R16.1
unnamed: C24.2, D3.2 (A), R17.1, RV2.2
unnamed: D3.1 (K), R17.2, R18.1
unnamed: D6.1 (K), D7.1 (K)
unnamed: C21.2, C25.2, D7.2 (A), Q4.3 (G), R16.2
unnamed: C22.2, C26.2, D8.2 (A), Q5.3 (G), R18.2
unnamed: D8.1 (K), D9.1 (K)
unnamed: C15.1, J2.1 (In)
unnamed: C29.2, J5.1 (In)
unnamed: Q1.3 (D), RV1.3, RV2.3
unnamed: C19.2, Q1.1 (G), R9.2
unnamed: C17.2, C18.2, Q1.2 (S), U5.1 (VO)
unnamed: Q3.1 (B), RV1.1, RV2.1
unnamed: C27.1, C28.1, Q4.1 (D), R19.1, T2.3 (SA)
unnamed: C27.2, C28.2, Q5.1 (D), R20.1, T2.5 (SB)
unnamed: C15.2, T1.1 (AA)
unnamed: R13.1, R14.1, T1.3 (SA)
unnamed: R12.1, R14.2, T1.5 (SB)
unnamed: C29.1, T2.2 (AB)
unnamed: R7.2, U3.3 (AIN), U4.3 (OUT)
unnamed: C6.2, C7.2, L2.2, L3.2, R4.1, R5.1, U3.1 (VDD)

File K9HZ_100W_PA/K9HZ_100W_BOM.csv:

"Reference","Value","Footprint","Qty","Mouser Part Number"
"C2,C4,C7,C9,C10,C15,C18,C20,C23,C24","0.1uF 50V","Capacitor_SMD:C_1206_3216Metric","10","581-12065F104K4"
"C3","2.2uF 6V","Capacitor_SMD:C_1206_3216Metric","1","80-C1206C225K5R"
"C5","1uF 16V","Capacitor_SMD:C_1206_3216Metric","1","187-CL31B105KBHNNNE "
"C6","10uF 6V","Capacitor_SMD:C_1206_3216Metric","1","187-CL31A106KBHNNNE"
"C11,C12,C13,C14,C29","0.1uF","-- mixed values --","5","-- mixed values --"
"C16,C17","1uF 50V","Capacitor_SMD:C_1206_3216Metric","2","187-CL31B105KBHNNNE "
"C19,C21,C22","0.01uF 50V","Capacitor_SMD:C_1206_3216Metric","3","80-C1206C103K5R7210 "
"C25,C26","4.7nF 100V","Capacitor_SMD:C_1206_3216Metric","2","80-C1206C472K5R "
"C27,C28","470pF 200V","Capacitor_SMD:C_1812_4532Metric_Pad1.57x3.40mm_HandSolder","2"," 581-100B471KT200XT "
"D1","7.1V 1W","Diode_SMD:D_SOD-323_HandSoldering","1","755-UFZVTE-177.5B"
"D2,D3","1N4148","Diode_SMD:D_SOD-523","2","621-1N4148WT"
"D6,D7,D8,D9","3.6V","Diode_THT:D_DO-35_SOD27_P7.62mm_Horizontal","4","637-ZPD3B6"
"J1","BANDS","Connector_IDC:IDC-Header_2x05_P2.54mm_Vertical","1",""
"J2","RF_IN","Connector_Coaxial:SMA_Amphenol_901-144_Vertical","1",""
"J4","12V, 20A","TerminalBlock:TerminalBlock_bornier-2_P5.08mm","1",""
"J5","RF_OUT","Connector_Coaxial:SMA_Amphenol_901-144_Vertical","1",""
"J7","Temp monitor","Connector_PinHeader_2.54mm:PinHeader_1x04_P2.54mm_Vertical","1",""
"L2,L3","FB","-- mixed values --","2","-- mixed values --"
"Q1","BSS84","Package_TO_SOT_SMD:SOT-23","1","512-BSS84"
"Q2","BS170","Package_TO_SOT_THT:TO-92_Inline","1","512-BS170"
"Q3","BD677","Package_TO_SOT_THT:TO-126-3_Horizontal_TabUp","1","511-BD677"
"Q4,Q5","RD100HHF1C","-- mixed values --","2",""
"R4,R5","5k6","Resistor_SMD:R_1206_3216Metric","2","279-CRGCQ1206F5K6"
"R7","3.0k 1%","Resistor_SMD:R_1206_3216Metric","1","603-RT1206FRE073KL"
"R8","0.005 Ohm 4W","Resistor_SMD:R_2010_5025Metric_Pad1.40x2.65mm_HandSolder","1","755-GMR50HJAAFD5L00"
"R9","3k","Resistor_SMD:R_1206_3216Metric","1","603-RT1206FRE073KL"
"R10","510R","Resistor_SMD:R_1206_3216Metric","1","603-RT1206FRE07510RL"
"R11","6k8","Resistor_SMD:R_1206_3216Metric","1","279-CRGCQ1206F6K8"
"R12,R13","10R","Resistor_SMD:R_1206_3216Metric","2","279-CRG1206F10R"
"R14","200R 2W","Resistor_THT:R_Axial_DIN0411_L9.9mm_D3.6mm_P12.70mm_Horizontal","1","279-EP2WSS200RJ"
"R15,R17","220R","Resistor_SMD:R_1206_3216Metric","2","279-CRG1206F220R"
"R16,R18","10R 1W","Resistor_SMD:R_2010_5025Metric_Pad1.40x2.65mm_HandSolder","2","652-CMP2010-FX-10R0L"
"R19,R20","150R 3W","Resistor_THT:R_Axial_DIN0614_L14.3mm_D5.7mm_P25.40mm_Horizontal","2","279-EP3WSS150RJ"
"RV1,RV2","500R","Potentiometer_THT:Potentiometer_Bourns_3296W_Vertical","2","652-3296W-1-501LF"
"T1","BN43-2402","T41_Library:Toroid_6Pin_BN-43-2402_7mm_6.2mm","1",""
"T2","BN43-3312","T41_Library:Toroid_6Pin_BN-43-3312_19.5mm_25.4mm","1",""
"U2","AP7381-33Y-13","Package_TO_SOT_SMD:SOT-89-3","1","621-AP7381-33Y-13"
"U3","MCP3021A0T-E/OT","Package_TO_SOT_SMD:SOT-23-5_HandSoldering","1","579-MCP3021A0T-E/OT"
"U4","ZXCT1010","Package_TO_SOT_SMD:SOT-23-5","1","522-ZXCT1010E5TA"
"U5","L4931CDT50","Package_SO:SO-8_3.9x4.9mm_P1.27mm","1","511-L4931CDT50-TR"
