# Repository DRWJSCHMIDT/T41 (continued)

## KiCad design K9HZ_100W_PA/K9HZ_100W_TempMonitor_KiCad/K9HZ_100W_TempMonitor_KiCad.kicad_pcb

Parts:
C1, C8: 0.1uF 50V; C_1206_3216Metric; Mouser Part Number 581-12065F104K4
H1, H2, H3, H4: MountingHole_2.7mm_M2.5_DIN965_Pad
J3: Over-Temp Alarm; PinHeader_1x02_P2.54mm_Vertical
J7: Temp monitor; PinHeader_1x04_P2.54mm_Vertical
JP1, JP2, JP3: SolderJumper_2_Open; SolderJumper-2_P1.3mm_Open_TrianglePad1.0x1.5mm
L1: FB; L_Axial_L5.3mm_D2.2mm_P7.62mm_Horizontal_Vishay_IM-1; Mouser Part Number 81-BLM31KN601BH1L
L2: FB; L_1206_3216Metric_Pad1.22x1.90mm_HandSolder; Mouser Part Number 875-HZ1206E601R-10
R1, R2, R3: 3k3; R_1206_3216Metric; Mouser Part Number 279-CRGCQ1206F3K3
R6: 10k; R_1206_3216Metric; Mouser Part Number 279-CRGCQ1206F10K
U1: ADT75; MSOP-8_3x3mm_P0.65mm; Mouser Part Number 584-ADT75ARMZ-R

Connections:
+3V3: J7.4, L1.1, L2.1
/SCL: J7.1, U1.2 (SCL)
/SDA: J7.2, U1.1 (SDA)
GND: C1.1, C8.1, H1.1, H2.1, H3.1, H4.1, J3.2, J7.3, JP1.1 (A), JP2.1 (A), JP3.1 (A), U1.4 (GND)
unnamed: C8.2, J3.1, R6.2, U1.3 (~OS/ALERT)
unnamed: JP1.2 (B), R1.2, U1.7 (A0)
unnamed: JP2.2 (B), R2.2, U1.6 (A1)
unnamed: JP3.2 (B), R3.2, U1.5 (A2)
unnamed: C1.2, L1.2, L2.2, R1.1, R2.1, R3.1, R6.1, U1.8 (VDD)

Notes on the sheet:
Temperature monitor
Board mounting holes
Place on heat sink for temp measurement

Board: 2 copper layers, 32.4 x 24.8 mm, 18 parts (1 on the bottom side), 9 nets.

File K9HZ_100W_PA/K9HZ_100W_PA_BOM/K9HZ_100W_TmpeMonitor_BOM.csv:

"Reference","Value","Footprint","Qty","Mouser Part Number"
"C1,C8","0.1uF 50V","Capacitor_SMD:C_1206_3216Metric","2","581-12065F104K4"
"J3","Over-Temp Alarm","Connector_PinHeader_2.54mm:PinHeader_1x02_P2.54mm_Vertical","1",""
"J7","Temp monitor","Connector_PinHeader_2.54mm:PinHeader_1x04_P2.54mm_Vertical","1",""
"L1,L2","FB","-- mixed values --","2","-- mixed values --"
"R1,R2,R3","3k3","Resistor_SMD:R_1206_3216Metric","3","279-CRGCQ1206F3K3"
"R6","10k","Resistor_SMD:R_1206_3216Metric","1","279-CRGCQ1206F10K"
"U1","ADT75","Package_SO:MSOP-8_3x3mm_P0.65mm","1","584-ADT75ARMZ-R"

## KiCad design T41_V012_Files_01-15-24/T41_V012_KiCad/T41-main-board-V012/T41-main-board-V012.kicad_pcb

Parts:
C1, C6, C7: 470uF 25V; CP_Radial_D10.0mm_P5.00mm; Mouser 667-ECA-1EM471
C2, C3, C8, C9, C10, C11, C13, C14, C16, C19, C20, C23, C24, C26, C31: 0.1uF 50V; C_1206_3216Metric; Mouser C1206C104K5RACTU
C4, C12, C15, C17, C18, C21, C22, C25, C27, C30, C33: 10uF 16V; C_1206_3216Metric; Mouser 80-C1206C106K4P
C5: 1uF 50V; C_1206_3216Metric; Mouser 187-CL31B105KBHNNNE
C28, C29: 2.2uF 16V; C_1206_3216Metric; Mouser 80-C1206C225K5R
C32, C34: 2.2nF; C_1206_3216Metric; Mouser 80-C1206C222K5RAC
D1: 1N4007; D_SMA; Mouser 621-S1A-F
D2, D3, D4: LED; D_1206_3216Metric; Mouser 645-599-0220-007F
D5: 10V; D_SMA; Mouser 78-MMSZ5240C-E3-08; not fitted
H5, H6: MountingHole_4.3mm_M4_DIN965_Pad
H7, H8: EA-T220-38E; EAT22038E; Mouser Part Number 588-EA-T220-38E
J1: +12V; PinHeader_1x02_P5.08mm_Vertical
J2: Fan1; PinHeader_1x02_P2.54mm_Vertical
J3: Acc; IDC-Header_2x04_P2.54mm_Vertical
J4: 12-13.8V; PinHeader_1x02_P5.08mm_Vertical
J5: Front Panel; IDC-Header_2x05_P2.54mm_Vertical
J6: RF CONTROL; IDC-Header_2x05_P2.54mm_Vertical
J7: Display; IDC-Header_2x05_P2.54mm_Vertical
J8: Display Voltage; PinHeader_1x03_P2.54mm_Vertical
J9: Keys/PTT; IDC-Header_2x03_P2.54mm_Vertical
J10: Conn_01x02; PinHeader_1x02_P2.54mm_Vertical
J11: ENCODER; IDC-Header_2x05_P2.54mm_Vertical
J12: BANDS; IDC-Header_2x05_P2.54mm_Vertical
J13: Header; PinHeader_1x02_P2.54mm_Vertical
J14: Rec_Out; Jack_3.5mm_STX-3081_Horizontal; Mouser 490-SJ1-3515N
J15: Rec_In; Jack_3.5mm_STX-3081_Horizontal; Mouser 490-SJ1-3515N
J16: Mic_In; Jack_3.5mm_STX-3081_Horizontal; Mouser 490-SJ1-3515N
J17: Ex_Out; Jack_3.5mm_STX-3081_Horizontal; Mouser 490-SJ1-3515N
J18: Conn_01x02; PinHeader_1x02_P2.54mm_Vertical; not fitted
J19, J20, J21: Conn_01x01; PinHeader_1x01_P2.54mm_Vertical
J22: Header; PinHeader_1x03_P2.54mm_Vertical
J23: Ethernet; IDC-Header_2x03_P2.54mm_Vertical; Mouser 710-61200621621
J24: USBHost; IDC-Header_2x03_P2.54mm_Vertical; Mouser 710-61200621621
L1, L2, L3: 10uH 20%; L_Bourns-SRN6028; Mouser 81-1264EY-100MP3
M1: Fan; Mouser 664-AD0412HXK96XT1
Q1: SUP90P06-09L; TO-220-3_Vertical; not fitted
Q2, Q3: 2N7000; TO-92_Inline; Mouser 512-2N7000BU
Q4: SUP90P06-09L; TO-220-3_Vertical
R1, R2: 10K; R_1206_3216Metric; Mouser CRCW120610K0FKEB
R3, R8, R9, R14: 1K; R_1206_3216Metric; Mouser CRCW12061K00JNEAC
R4, R5: 220R; R_1206_3216Metric; Mouser 279-CRGCQ1206J220R
R6, R11, R12: 100R; R_1206_3216Metric; Mouser 652-CR1206FX-1000ELF
R7: 2K2; R_1206_3216Metric; Mouser CRCW12062K20JNEAC
R10, R13: 470R; R_1206_3216Metric; Mouser CRCW1206470RJNEAC
R15: 150R; R_1206_3216Metric; Mouser 279-CRGCQ1206J150R
R16: 100k; R_1206_3216Metric; Mouser 71-CRCW1206100KFKEB; not fitted
SW1: ON-OFF BUTTON; PinHeader_1x02_P2.54mm_Vertical
TP1, TP2: TestPoint; PinHeader_1x01_P2.54mm_Vertical
U1: LM7805CT; TO-220-3_Vertical; Mouser 926-LM7805CT/NOPB
U2: AP7384-50V; TO-92_Inline_Wide; Mouser AP7381-50V-A
U3: LM1117T-3.3; TO-220-3_Vertical; Mouser 926-LM1117T-3.3/NOPB
U4: ATtiny85-20S; DIP-8_W7.62mm_Socket; Mouser 556-ATTINY85-20PU
U5: PCM5102; TSSOP-20_4.4x6.5mm_P0.65mm; Mouser 595-PCM5102APWR
U6: PCM1808PW; TSSOP-14_4.4x5mm_P0.65mm; Mouser 595-PCM1808PW
U7: Teensy_Audio_Adaptor
U8: Teensy4.1; Teensy41
U9: LM7805CT; TO-220-3_Vertical; Mouser 926-LM7805CT/NOPB; not fitted
U10: LM1117T-3.3; TO-220-3_Vertical; Mouser 926-LM1117T-3.3/NOPB; not fitted

Connections:
+3V3: C14.1, C15.1, C16.1, C17.1, C18.1, C19.1, C24.1, C25.1, D2.2 (A), J5.3, J5.4, J8.3, J11.3, J11.4, L3.2, R7.2, TP2.1, U5.1 (CPVDD), U5.8 (AVDD), U5.20 (DVDD), U6.4 (VDD)
+5V: C11.1, C22.1, C23.1, D3.2 (A), J3.7, J8.1, L1.2, TP1.1, U6.3 (VCC), U8.48 (VIN)
+12P: J4.2, L2.2
+12V: C3.1, C6.1, C31.1, D5.1 (K), J1.2, J2.1, Q1.3 (S), Q4.2 (D), R15.2, U1.1 (VI), U3.3 (VI), U9.1 (VI), U10.3 (VI)
/A21: J3.4, U8.32 (40_A16)
/A22: J3.6, U8.33 (41_A17)
/ADC_IN: U6.9 (DOUT), U8.8 (6_OUT1D)
/BAND0 (80m): J12.1, U8.22 (30_CRX3)
/BAND1 (40m): J12.2, U8.23 (31_CTX3)
/BAND2 (20m): J12.3, U8.20 (28_RX7)
/BAND3 (15m): J12.4, U8.21 (29_TX7)
/BCK: R11.1, U5.13 (BCK), U7.21 (BCLK), U8.43 (21_A7_RX5_BCLK1)
/BEGIN TEENSY SHUTDOWN: U4.6 (PB1), U8.2 (0_RX1_CRX2_CS1)
/CLK: R6.1, U7.23 (MCLK), U8.45 (23_A9_CRX1_MCLK1)
/CW on/off: J6.7, U8.25 (33_MCLK2)
/Cal: J6.10, U8.30 (38_CS1_IN1)
/C/S: J7.6, U8.12 (10_CS_MQSR)
/D+: J24.3, U8.57 (D+)
/D-: J24.6, U8.56 (D-)
/DAUDIO_OUT: U5.14 (DIN), U8.24 (32_OUT1B)
/FOR: J12.6, U8.18 (26_A12_MOSI1)
/INT1: J5.6, U8.36 (14_A0_TX3_SPDIF_OUT)
/INT2: J5.8, U8.37 (15_A1_RX3_SPDIF_IN)
/Key1 in: J3.3, J9.6, U8.28 (36_CS)
/Key2 in: J3.1, J9.4, U8.27 (35_TX8)
/LED: J23.3, U8.61 (LED)
/LRCK: R12.1, U5.15 (LRCK), U7.20 (LRCLK), U8.42 (20_A6_TX5_LRCLK1)
/MISO: R4.2, U8.14 (12_MISO_MQSL)
/MOSI: R5.1, U8.13 (11_MOSI_CTX1)
/Matrix: J5.9, U8.31 (39_MISO1_OUT1A)
/PTT in: J3.5, J9.3, J16.R, U8.29 (37_CS)
/R+: J23.5, U8.60 (R+)
/R-: J23.6, U8.65 (R-)
/REF: J12.8, U8.19 (27_A13_SCK1)
/RXTX: D4.2 (A), J6.9, J10.1, J12.10, U8.44 (22_A8_CTX1)
/Rx: U7.8 (Rx), U8.10 (8_TX2_IN1)
/SCL: J6.1, J18.2, U7.19 (SCL), U8.41 (19_A5_SCL)
/SCL1: J5.5, U8.38 (16_A2_RX4_SCL1)
/SCL2: J12.7, U8.16 (24_A10_TX6_SCL2)
/SCLK: J7.3, U8.35 (13_SCK_LED)
/SDA: J6.3, J18.1, U7.18 (SDA), U8.40 (18_A4_SDA)
/SDA1: J5.7, U8.39 (17_A3_TX4_SDA1)
/SDA2: J12.5, U8.17 (25_A11_RX6_SDA2)
/T+: J23.2, U8.63 (T+)
/T-: J23.1, U8.62 (T-)
/TEENSY SHUTDOWN COMPLETE: U4.7 (PB2), U8.3 (1_TX1_CTX2_MISO1)
/Tx: U7.7 (Tx), U8.9 (7_RX2_OUT1A)
/Xmit Mode: J6.6, U8.26 (34_RX8)
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C8.2, C9.2, C10.2, C11.2, C12.2, C13.2, C14.2, C15.2, C16.2, C17.2, C18.2, C19.2, C20.2, C21.2, C22.2, C23.2, C24.2, C25.2, C26.2, C27.2, C28.2, C31.2, C32.1, C34.2, H5.1, H6.1, J1.1, J2.2, J3.8, J4.1, J5.1, J5.2, J6.2, J6.4, J6.5, J7.9, J7.10, J9.1, J10.2, J11.1, J11.2, J12.9, J14.S, J15.S, J19.1, J20.1, J21.1, J23.4, J24.4, Q2.1 (S), Q3.1 (S), R2.2, R3.2, R8.1, R9.1, R14.1, R16.2, U1.2 (GND), U2.2 (GND), U3.1 (GND), U4.4 (GND), U5.3 (CPGND), U5.9 (AGND), U5.10 (DEMP), U5.11 (FLT), U5.12 (SCK), U5.16 (FMT), U5.19 (DGND), U6.2 (AGND), U6.5 (DGND), U6.10 (MD0), U6.11 (MD1), U6.12 (FMT)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
unnamed: C30.1, C32.2, R10.1
unnamed: C30.2, J14.R
unnamed: C33.1, C34.1, R13.1
unnamed: C33.2, J14.T
unnamed: D1.2 (A), L2.1, Q1.2 (D), Q4.3 (S), R1.1
unnamed: C5.1, D1.1 (K), U2.3 (VI)
unnamed: D2.1 (K), R8.2
unnamed: D3.1 (K), R9.2
unnamed: D4.1 (K), R14.2
unnamed: D5.2 (A), Q1.1 (G), Q2.2 (G), Q3.3 (D), Q4.1 (G), R1.2, R16.1
unnamed: J5.10, U8.46 (3V3)
unnamed: J7.4, R5.2
unnamed: J7.5, R4.1
unnamed: C12.1, C13.1, J7.7, J7.8, J8.2
unnamed: J11.5, U8.4 (2_OUT2)
unnamed: J11.6, U8.6 (4_BCLK2)
unnamed: J11.7, U8.5 (3_LRCLK2)
unnamed: J11.8, U8.7 (5_IN2)
unnamed: J13.1, J16.S
unnamed: J13.2, J16.T
unnamed: J17.T, J22.1
unnamed: J17.S, J22.2
unnamed: J17.R, J22.3
unnamed: J24.5, U8.55 (5V)
unnamed: Q2.3 (D), R15.1
unnamed: Q3.2 (G), R2.1, U4.3 (XTAL2/PB4)
unnamed: C1.1, C2.1, L1.1, U1.3 (VO), U9.3 (VO)
unnamed: C4.1, C9.1, SW1.1, U2.1 (VO), U4.8 (VCC)
unnamed: C10.1, R3.1, SW1.2, U4.2 (XTAL1/PB3)
unnamed: C29.2, U5.4 (CAPM)
unnamed: C29.1, U5.2 (CAPP)
unnamed: C20.1, C21.1, U5.18 (LDOO)
unnamed: R13.2, U5.6 (OUTL)
unnamed: R10.2, U5.7 (OUTR)
unnamed: C28.1, U5.5 (VNEG)
unnamed: R7.1, U5.17 (XSMT)
unnamed: R11.2, U6.8 (BCK)
unnamed: R12.2, U6.7 (LRCK)
unnamed: R6.2, U6.6 (SCKI)
unnamed: J15.R, U6.13 (VIN_L)
unnamed: J15.T, U6.14 (VIN_R)
unnamed: C26.1, C27.1, U6.1 (VREF)
unnamed: C7.1, C8.1, L3.1, U3.2 (VO), U10.2 (VO)

Notes on the sheet:
Various other
Voltage selection jumper
Heatsinks
Power section
Digitize RF input
Audio Output
Shutdown routine activation
Voltage reversal protection
Board mounting holes
Mounted in 8 pin socket
MIC INPUT Ring - PTT Top - MONO Audio
<-OR->
RF IN RING - Q - VIN_L TIP - U - VIN_R
I/Q OUTPUT Ring - Q Tip - I
AUDIO OUT RING - RIGHT TIP - LEFT
L_out
Microcontroller and connectors
"Empty" components to add PCB footprints for bottom-side mounting option
Off-board wires connect J22 and J13 to Teensy Audio Adaptor
Choose between "Shutdown routine activation" and "Voltage reversal prevention" sections Populate only one!
RFCONTROL SIGNALS: RxTx: H=Tx, L=Rx Xmit Mode: H=SSB, L=CW CW: H=ON, L=OFF
Exciter output and microphone input
R_out

Board: 4 copper layers, 100.0 x 100.0 mm, 102 parts (11 on the bottom side), 90 nets.

## Code that names these connections

File T41_V012_Files_01-15-24/T41_V012_Software/ATTiny85_On_Off_T41_Ver02/ATTiny85_On_Off_T41_Ver02.ino:

// Code for the T41 Easy radio ON and OFF routines.  This allows for a 
// special trigger from the ATTiny85 sent to the Tensy that causes it to
// run through special code in the teensy 4.1 before the radio shuts down.
// The special code could be code to save parameters that have changed.
//
//       Written by Dr. William J. Schmidt, II, Ph.D. - K9HZ
//
// I'm an excellent hardware engineer but a very shitty software engineer.
// Therefore, plagerize and modify away!  No warranty.  Just give me a little
// credit.

#define TOTAL_SHUTDOWN    2       // Positive pulse from Teensy tells ATTiny to complete shut down.
#define START_SHUTDOWN    1       // Positive pulse from ATTiny tells Teensy To begin shut down code.
#define PANEL_SWITCH      3       // Front panel switch to turn radio ON/OFF
#define FET_SWITCH        4       // HIGH=RADIO ON, LOW=RADIO OFF. FET switch connection.
//
// Variables:
//
bool CurrentStateOn; 
//
void setup() {
  // Set up the Input and Output pins as follows://
  // PIN 7 - PB2 - INPUT.   Positive pulse from Teensy tells ATTiny to complete shut down.
  // PIN 6 - PB1 - OUTPUT.  Positive pulse from ATTiny tells Teensy To begin shut down code.
  // PIN 2 - PB3 - INPUT.   Push Button INPUT for turn radio ON and OFF.
  // PIN 3 - PB4 - OUTPUT.  HIGH=RADIO ON, LOW=RADIO OFF. FET switch connection.
  pinMode(TOTAL_SHUTDOWN, INPUT);
  pinMode(START_SHUTDOWN, OUTPUT);
  pinMode(PANEL_SWITCH,   INPUT);
  pinMode(FET_SWITCH,     OUTPUT);

  // Set initial state to "radio off" initially
  digitalWrite(FET_SWITCH,     LOW);        //RADIO OFF - Shut off power FET
  digitalWrite(START_SHUTDOWN, LOW);        //Prepare for RADIO ON - Tell Teensy that 
  CurrentStateOn = false;                   // No switchPush to start
}

void loop() 
{  // Read pushbutton switch
  if (digitalRead(PANEL_SWITCH) == HIGH) {  // Test for a push button for pushed state - change status
    if (CurrentStateOn == true) {           // IF we are already "ON" and the button was pushed, start 
      digitalWrite(START_SHUTDOWN, LOW);    // the Shutdown by setting the start shutdown line to the teensy high...
      delay(5000L);                         // and then wait a five seconds so we don't just trigger the radio to the "ON" state immediately 
    } else {                                // Otherwise we are "OFF" and we should turn the radio "ON"" because the switch was pushed
      digitalWrite(FET_SWITCH, HIGH);       // Start by turning the FET switch "ON" to boot the Teensy and start the radio.
      CurrentStateOn = true;                // and make a note that we turned on the radio.
      delay(3000L);                         // Wait 3 seconds so we don't just accidntally just turn the switch off again.
    }
  }
  //
  // test to see if the radio is currently "ON" and the the teensy says shut "OFF" because it has completed
  // the execution of the shut down code and the ATTiny can complete the shut down process.
  //
  if (CurrentStateOn == true) {
    if (digitalRead(TOTAL_SHUTDOWN) == HIGH) {   // Teensy says we are through the shutdown code.  Just shut down now.
      digitalWrite(FET_SWITCH, LOW);        // Set the FET switch to "OFF".
      digitalWrite(START_SHUTDOWN, LOW);    // Prepare for RADIO ON - Tell Teensy that 
      CurrentStateOn = false;               // and remember we shut off the radio for next pass.
      delay(1000L);                         // Wait a second while so we don't just trigger an "ON" state accidentally.
    }
  }
} // LOOP

File T41_V010_Files/T41_V010_Source_Code/SDTVer010/SDTVer010_(1).h (part):

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#include <utility/imxrt_hw.h>                       // for setting I2S freq, Thanks, FrankB!
#include <EEPROM.h>

//======================================== Symbolic Constants for Debugging and Version Control ========================
#define VERSION                     "V010  "
#define RIGNAME                     "T41-EP SDT"
#define SPLASH_DELAY                1000L         // Probably should be 4000 to actually read it
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#define T4                                        // Says we are using a Teensy 4 or 4.1
#define RA8875_DISPLAY              1             // Comment out if not using RA8875 display

#define DEBUG                       1             // This must be uncommented for ANY debugging statements to work
//#define STORE_SWITCH_VALUES                       // Uncomment to save the analog switch values for your push button matrix

#define OFF                         0
#define ON                          1
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
//======================================== Symbolic constants ==========================================================

// These constants are used by the voltage divider network so only 1 analog pin is used for the 16 option switches. These may need
// to be changed for the exact value for your system. They are initialized in the INO file.

#define BUSY_ANALOG_PIN              39     // This is the analog pin that controls the 16 switches
#define NOTHING_TO_SEE_HERE         950     // If the analog pin is greater than this value, nothing's going on
#define BOGUS_PIN_READ               -1     // If no push button read
#define WIGGLE_ROOM                  15     // This is the number of pixels within which a switch analog value must fall
#define SWITCH_DEBOUNCE_DELAY       50L     // Milliseconds for the switch to settle down
#define NUMBER_OF_SWITCHES           16     // Number of push button switches
#define CHAR_HEIGHT                  32
#define PIXELS_PER_EQUALIZER_DELTA   10     // Number of pixeks per detent of encoder for equalizer changes
#define AUDIO_PLOT_CEILING          119     // (SPECTRUM_BOTTOM - AUDIO_SPECTRUM_TOP)

#define TOP_MENU_COUNT               16     // Menus to process
#define MAX_FAVORITES                10     // Max number of favorite frequencies stored in EEPROM
#define PRIMARY_MENU                  0
#define SECONDARY_MENU                1
#define SELECTED_INDEX                3     // This is the index for MENU_OPTION_SELECT

/*
  const char *topMenus[]                    = {"CW",              "Display Choices", "Spectrum Set",   "AGC",        "NR Set",
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#define UNUSED_1                    14
#define UNUSED_2                    12
//=======================================================
//#define XPIXELS             320           // This is for the standard 2.8" display
//#define YPIXELS             240
//#define XPIXELS             480           // This is for the standard 3.5" display
//#define YPIXELS             320
#define XPIXELS               800           // This is for the 5.0" display
#define YPIXELS               480
#define PIXELHEIGHT           20            // Used in fillRec() to erase a line

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#define SMETER_BAR_HEIGHT     18
#define SMETER_BAR_LENGTH     180
#define SPECTRUM_NOISE_FLOOR  (SPECTRUM_TOP_Y + SPECTRUM_HEIGHT - 3)
#define TIME_X                (XPIXELS * 0.73)                            // Upper-left corner for time
#define TIME_Y                (YPIXELS * 0.07)
#define WHICH_SIDEBAND_X      (XPIXELS * 0.70)
#define WHICH_SIDEBAND_Y      (YPIXELS * 0.20)
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#define VFOB_PIXEL_LENGTH     280
#define FREQUENCY_PIXEL_HI    45
// Offsets for status info
#define FIELD_OFFSET_X        WATERFALL_RIGHT_X + 118                     // X coordinate for field
#define NOTCH_X               WATERFALL_RIGHT_X + 58
#define NOTCH_Y               WATERFALL_TOP_Y   + 90
#define NOISE_REDUCE_X        WATERFALL_RIGHT_X + 58
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#define HISTOGRAM_ELEMENTS      750
#define LOWEST_ATOM_TIME         20                   // 60WPM has an atom of 20ms
#define HIGHEST_ATOM_TIME       240                   // 5WPM has an atom of 240ms                              
#define DIT_WEIGHT              0.3                   // Previous values account for 90% of average
#define AVERAGE_DIT_WEIGHT      0.7                   // The number above and this one must equal 1.0
#define DITLENGTH_OBSERVATIONS  10                    // Number of ditlength observations to compute average
#define ADAPTIVE_SCALE_FACTOR   0.8                   // The amount of old histogram values are presesrved
#define SCALE_CONSTANT          (1.0 / (1.0 - ADAPTIVE_SCALE_FACTOR)) // Insure array has enough observations to scale
#define FILTER_WIDTH            25                    // The default filter highlight in spectrum displah
#define ZOOM_2X_BIN_COUNT       187.5                 // The 2x bin count for display

#define AUDIO_POST_PROCESSOR_BANDS  8                     // Number of audio segments
#define EEPROM_FAVORITES_X          100
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#define NO_DISPLAY            3
#define NOISE_DISPLAY         4

#define FLOAT_PRECISION       6                 // Assumed precision for a float
#define BUFFER_SINE_COUNT     7                 // Leads to a 750Hz signal

#define EQUALIZER_CELL_COUNT  14
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#define NOISE_SAMPLE_SIZE         500
#define SD_MULTIPLIER             3
#define NOISE_MULTIPLIER          0.5         // Signal must be this many time greater than the noise floor
#define STARTING_DITLENGTH        80          // dit length for 15wpm

#ifndef RA8875_DISPLAY
#include <ILI9488_t3.h>                     // https://github.com/mjs513/ILI9488_t3
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#endif

#define MOSELEY                     0
#define TIMEZONE                    "EST: "     // Set for eastern time
//#define CHANG                     0
#define MOSELEY                     0

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#define FREQ_SEP_CHARACTER          '.'

//========================================================= Pin Assignments =====================================
//========================================= Pins 0 and 1 are usually reserved for the USB COM port communications
//========================================= On the Teensy 4.1 board, pins GND, 0-12, and pins 13-23, 3.3V, GND, and
//========================================= Vin are "covered up" by the Audio board. However, not all of those pins are
//========================================= actually used by the board. See: https://www.pjrc.com/store/teensy3_audio.html
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#define FILTERPIN40M                31    // 40M filter relay
#define FILTERPIN20M                28    // 20M filter relay
#define FILTERPIN15M                27    // 15M filter relay
#define RXTX                        22    // Transmit/Receive
#define PTT                         37    // Transmit/Receive
#define MUTE                        38    // Mute Audio,  HIGH = "On" Audio available from Audio PA, LOW = Mute audio
//========================================= Switch pins
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#define MENU_MINUS                  106    // Menu decrement
#define MENU_PLUS                   107    // this is the menu button pin
#define CHANGE_NOISE                108    // this is the pushbutton pin of NR
#define CHANGE_DEMOD                109    // this is the push button for demodulation
#define CHANGE_ZOOM                 110    // Push button for display zoom feature
#define SET_FREQ_CURSOR             111    // Push button for frequency Cursor feature  was 39 for Al

//========================================= Keyer pins
//#define TONEPIN                     xx    // For sidetone
#define KEYER_DIT_INPUT_TIP          35    // Tip connection for keyer
#define KEYER_DAH_INPUT_RING         36    // Ring connection for keyer  -- default for righthanded user

#define OPTO_OUTPUT                  24    // To optoisolator and keyed circuit
#define STRAIGHT_KEY                  0
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#define CONFIG_VERSION "mr1"  //mdrhere ID of the E settings block, change if structure changes
#define CONFIG_START 0                      // Address start the EEPROM data. (emulated with size of 4K. Actual address managed in library)

#define TERMCHRXWIDTH               9       // print stuff for text terminal
#define TERMCHRYWIDTH               10
#define TERMNROWS                   4  // 15 
#define TERMNCOLS                   28 // 34 
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
## Commit log (part)

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2024-01-12 First Commit to main
    First Commit to main
2024-01-15 Original Commit
    K9HZ 20W 1-54MHz PA
2024-01-15 Initial Commit
    K9HZ Digital Attenuator Files
2024-01-15 Renamed all files to replaces spaces with underscores
2024-01-17 Updated To Most Resent Versions
2024-01-17 Updated Latest Versions
2024-01-17 Added KiCad projects for all boards
2024-01-17 Corrected typo on band code for no-filter option
2024-01-18 Fixed stackup ambiguity in LPF relay carrier board. It is a 2 layer board but KiCad stackup contained two unused inner copper layers
2024-01-24 Fixed errors
    Fixed a few errors in BOMs
2024-01-24 Updated BPF
    Updated PBF
2024-01-24 Update For BPF Development
    Update for BPF Development
2024-01-25 Added Board Pictures
    Added Board Pictures
2024-01-25 Update K9HZ_LPF-Control_Board_BOM_V1.00_01-14-24.xlsx
    Updated LPF BOM
2024-01-26 Updated RF Board
    Updated RF board
2024-01-26 Updated BPF Design files
    Updated BPF Design Files
2024-01-26 Switched order of attenuator and amplifier in receive chain. Now attenuator is before amplifier
2024-01-26 Added 11 band BPF design files for prototyping
2024-01-26 Moved production files for RF board with switched amp and attenuator to correct locations
2024-01-26 Added 3D model pictures of exciter filter
2024-01-26 Update RF board
    Update RF Board
2024-01-27 Renamed some files to keep to the conventions
2024-01-27 Removed references to Software
    Removed References to Software
2024-01-29 Update K9HZ_LPF-Filter_Board_BOM_V1.00_01-10-24.xlsx
    Updated LPF BOM
2024-01-29 Recent update
    Recent update
2024-01-29 Update
    Update
2024-02-03 Fixed incorrect grounding of heatsink feet on main board
2024-02-04 Added 1206 footprints alongside all the coil inductors in the BPF board to allow use of SMD inductors instead of toroids
2024-02-06 Moved heatsink up slightly on main board to avoid board edge
2024-02-06 Update 020524
    Update 020524
2024-02-06 Restored silkscreen registration dot on U2 of RF board to its rightful place
2024-02-08 Latest Updates
    Latest Updates
2024-02-08 Corrected callsign for Bill on the BPF board silkscreen
2024-02-11 VHF Updates
    VHF Updates
2024-02-11 Corrected Names
    Corrected File Names
2024-02-12 Fixes to LPF as part of checkout
2024-02-14 Send Routines file
    Send Routines file
2024-02-14 Recreate these
2024-02-14 Fixes to LPF control board based on KI3P testing
2024-02-14 To match remote
2024-02-15 Update for LPF BOM
    Update for LPF BOM
2024-02-15 Update LPF Line Section Inductors
    Update LPF Line Section Inductors
2024-02-15 Delete K9HZ_LPF_BOM_V1.00_01-10-24.xlsx
    File Clean-up
2024-02-15 Update for RF Board BOM Part Error
    Update for RF Board BOM Part Error
2024-02-16 Removed incorrect LPF prototype gerbers
2024-02-16 Updates to LPF Docs
    Updates to LPF Docs
2024-02-17 Working on RF board mods
2024-02-17 Fixes to gitignore
2024-02-17 Added ground test points and pad, silkscreen edits
2024-02-17 Restoring files that mistakenly got deleted in branch merge
2024-02-17 Changed Q1 of main board to correct part FQP47P06
2024-02-17 Update for V12 Software Release
    Update for V12 Software Release
2024-02-18 Added Software
    Added Software
2024-02-18 Create PCB_Brackets_for_100mm_x_100mm_Boards.gcode
    Update For 3D Printed Stuff
2024-02-19 Update BOMs
    Make BOMs Easier to Read
2024-02-22 Update BPF Winding Data
    Update BPF Winding Data
2024-02-22 Updated 3D files
    Updated 2D FIles
2024-02-25 Fixed errata in KI3P RF board test report
2024-02-25 Corrected footprint for TCXO Y1
2024-02-25 Updated RF board BOM, gerbers, and PDF schematic to incorporate KI3Ps testing results
2024-02-25 Removed out of date gerbers and BOMs
2024-02-26 Added heatsink model to RF board to confirm component fit. Tweaked locations of a few components.
2024-02-26 Changed orientation of Q1 and D5 for reverse protection
2024-02-26 BPF Finalization
    BPF Finalization
2024-02-26 Update for Fan Bracket
    Update for Fan Bracket
2024-03-10 Fixes to BPF board, adding missing decoupling capacitors
2024-03-10 Additional fix to BPF board
2024-03-10 BPF Update
    BPF Update
2024-03-10 BPF Picture Update
    BPF Picture Update
2024-03-10 BPF Files Update
    BPF Files Update
2024-03-11 Update BPF
    Update BPF
2024-03-12 Added Arduino sketch and libraries for controlling ADF4351 LO
2024-03-12 Update Encoder Boards
    Update Encoder Boards
2024-03-17 Picture Updates
    Picture Updates
2024-03-18 Update BPF BOM
    Update BPF BOM
2024-03-20 Update BPF Files
    Update BPF Files
2024-03-23 Upgrade Path Documents Uploaded
    Upgrade Path Documents Uploaded
2024-03-23 Board Pictures Updated
    Board Pictures Updated
2024-03-25 Updated Board Pictures
    Updated Board Pictures
2024-04-08 Added CAL isolation jumper to RF board to improve Bode plot measurement
2024-04-10 Upgrade Paths
    Upgrade Paths
2024-04-11 Update Paths
    Update Paths
2024-04-13 Update Test Software
    Update Test Software
2024-04-13 Add Test Software
    Add Test Software
2024-04-14 Second Rx Adapter
    Second Rx Adapter
2024-04-15 2nd Rx Adapter Update
    2nd Rx Adapter Update
2024-04-15 Added second receiver adapter board
2024-04-15 Fixed BOM
    Fixed BOM
2024-04-17 Update BPFTest
    Update BPFTest
2024-04-20 Update Upgrade Path Diagrams
    Update Upgrade Path Diagrams
2024-04-20 Final fixes to BPF to change addressing of BYPASS path
2024-04-21 Added pulldown resistors to 12/10 and 17/15 diode combiners
2024-04-21 Update File Names
    Update File Names
2024-04-23 Upgrade Path Diagram Updates
    Upgrade Path Diagram Updates
2024-04-24 Updated BOMs
    Updates BOMs
2024-04-27 Incorporate final QC changes from Bill: add altenative MOSFET switch footprint for voltage reversal protection
2024-04-27 Small silkscreen tweaks: add diode cathode indicators
2024-04-27 Updated pictures
    Updated Pictures
2024-04-29 Added new code for Teensy shutdown control
2024-04-29 Update Pictures
    Update Pictures
2024-04-29 Update Software Items
    Update Software Items
2024-04-29 Rearranged Software Directories
    Rearranged Software Directories
2024-04-30 Update V12 BOMS
    Update V12 BOMs
2024-05-02 Removed some KI3P-specified configurations from the board testing code
2024-05-02 Update files
    Update Files
2024-05-02 Update LPF Specifications
    Update LPF Specifications
2024-05-03 Files Update
    Files Update
2024-05-23 File Updates
    File Updates
2024-06-03 Rearranged Files in 20W directory
    Rearranged Files in 20W PA Dir
2024-06-08 Update 20W PA Build Instructions
    Update 20W PA Build Instructions
2024-06-10 Directory Restructure
    Directory Restructure
2024-06-10 File Structure re-alignment
    File Structure re-alignment
2024-06-13 File additions
    File additions
2024-06-15 Updated LPF BOM
    Updated LPF BOM
2024-06-15 Update LPF BOM
    Update LPF BOM
2024-06-15 LC Updates
    LC Updates
2024-06-18 Fixed BPF BOM
    Fixed BPF BOM
2024-06-19 Add License Documents
    Add License Documents
2024-06-22 Changes to T41 library
2024-06-30 Updated silkscreen for RF Board Y1 to put indicator dot in the correct location
2024-06-30 Updates
    Updates
2024-07-02 BOM Update
    BOM Update
2024-07-07 Update Front Panel
    Update Front Panel
2024-07-08 FP Updates
    FP Updates
2024-07-10 Rearrange Files
    Rearrange FIles
2024-07-13 Added models to library
2024-07-14 New Files
    New Files
2024-07-16 File Update
    File Update
2024-07-16 Update BOM files
    Update BOM Files
2024-07-17 Update BOMs
    Update BOMs
2024-07-17 Added a few parts to the symbol library
2024-07-18 Added component to KiCad library
2024-07-18 Added R73 to RF board to adjust off ramp time
2024-07-20 Updated C5,C8,C19,C21 values per Al
2024-07-21 Added switching regular alternatives description
2024-07-25 Updated LPF carrier board schematic with 6.8k resistor value
2024-07-30 Update GITHUB for Reverse Voltage Protection Kits
    Update GITHUB for Reverse Voltage Protection Kits
2024-07-30 Update K9HZ_LPF_tester.ino
    Wrong pin being toggled for TX/RX test
2024-07-31 Rearranged files
    Rearranged Files
2024-08-01 Redundant changes
2024-08-01 Added Glen VK3PE toroid winding details to BPF schematic
2024-08-01 Update File
    Update File
2024-08-02 Added 100W PA design files
2024-08-02 Create ATTiny85_On_Off_T41_Jerry-KF6VB.ino
    Added Jerry KF6VB's code for the main board ATTiny85 that "hiccups" the power on startup to address display issues
2024-08-03 Fixed footprint of T2 in 100W PA
2024-08-04 Updated Order Pages
    Updated Order Pages
2024-08-05 Added silkscreen art for 100W amp bias pot control per Glenn VK3PE suggestion
2024-08-05 Update K9HZ-KI3P_Orders_080424.pdf
    Update Orders
2024-08-05 Update K9HZ-KI3P_Orders_080424.pdf
    Update Orders FIle
2024-08-08 Added ground pad hole for digital attenuators on RF board
2024-08-10 Increased diameter of via in RF board attenuators to 2mm
2024-08-12 Rename Files
    Rename Files
2024-08-19 Copyright Material Removed
    Copyright Material Removed
2024-08-19 Copyright
    Copyright
2024-08-25 Updated instructions in BPF schematic for second receiver
2024-08-25 Added wiring drawings for single receiver option
2024-09-08 Correct R35 and R37 to 0R on the RF board
2024-09-12 Delete Old Order FIle
    Delete Old Order FIle
2024-09-16 File Error Update
    File Error Update
2024-09-19 added printed case files
    added printed case files
2024-09-22 Update Order File
    Update Order File
2024-09-23 Update Orders
    Update Orders
2024-09-29 Added components to reference library
2024-09-29 Updates BOMs
    Updating BOMs
2024-10-02 Update K9HZ-KI3P_Orders_100124.pdf
    Update Orders
2024-10-05 order updates
    order updates
2024-10-09 Improved i2cscan to identify devices that are connected
2024-10-09 Fixed i2cscan README
2024-10-09 Added testing section to BPF assembly manual
2024-10-09 Move old BPF assembly manual
2024-10-10 Updated RVP Files
    Updated RVP files
2024-10-11 Changed the order of the BPF assembly slightly to accommodate switch testing
2024-10-11 Added Weather Station
    Added Weather Station
2024-10-11 Fixing directories
    Fixing directories
2024-10-11 Updating RVP Files
    Updating RVP Files
2024-11-05 Restructure Github
    Restructure Github
2024-12-13 RF board updates: removed clock divider, replaces IQ output caps with 0R, added cap to FB for TCXO
2025-01-16 Added bypass capacitor to TCXO, removed clock divider circuit, replaced I/Q output DC blocking capacitors with 0R resistors
2025-02-06 Update Boards
    Update Boards
2025-02-10 Rearrange GITHUB
    Rearrange GITHUB
2025-02-16 Clean up Display Adapter Files
    Cleaned up Display Adapter Files
2025-02-18 BPF Files Updates
    BPF Files Updated
2025-03-07 Update Calibration Instr
    Update Calibration Instr
2025-03-10 Calibration Update
    Calibration Update
2025-03-23 Added Display Driver Documents
    Added Display Driver Documents
2025-06-11 Added RF board testing sketch
2025-06-17 Fixed a bug in the RF tester and made the state machine shutdown time shorter
2025-08-28 Update ELSIE cfg file
    Update ELSIE cfg file
2025-12-26 T41 Mini
    T41 Mini
2025-12-27 T41 Mini Update
    T41 Mini Update
2025-12-27 Work in progress -- still need to add the clock daughter board
2025-12-27 Version of RF board with clock and attenuator daughterboards sent to Bill for comment
2025-12-28 Updated titles for schematics and printed to PDF
2025-12-30 H1 removed and some via transitions removed for reduced EMI
2025-12-31 New layouts for RF board, clock board, and attenuator board are done
2025-12-31 Changed transmit chain direction on schematic to match RF board
2026-01-03 RF board updated to reverse the direction of the transmit chain, making routing easier and less prone to noise.
2026-01-03 Added gerber files
2026-01-03 update mini
    Update mini
2026-02-04 Assembly Manual Update
    Assembly Manual Update
2026-02-23 Cleaned Up Design Documents
    Cleaned Up Design Documents
2026-03-17 Update New RF Board
    Update New RF Board
2026-04-07 Update New Boards
    Update New Boards
